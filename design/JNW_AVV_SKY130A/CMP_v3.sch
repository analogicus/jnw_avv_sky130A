v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 1310 -760 1310 -700 {
lab=#net1}
N 1350 -790 1400 -790 {
lab=pbias}
N 1090 -620 1130 -620 {
lab=ip}
N 1490 -620 1530 -620 {
lab=in}
N 1170 -540 1170 -430 {
lab=#net2}
N 1090 -390 1090 -370 {
lab=#net2}
N 1090 -430 1170 -430 {
lab=#net2}
N 1170 -430 1230 -430 {
lab=#net2}
N 1230 -430 1230 -390 {
lab=#net2}
N 1450 -540 1450 -430 {
lab=#net3}
N 1390 -430 1390 -390 {
lab=#net3}
N 1390 -430 1450 -430 {
lab=#net3}
N 1450 -430 1530 -430 {
lab=#net3}
N 1530 -390 1530 -370 {
lab=#net3}
N 1270 -360 1290 -360 {
lab=#net3}
N 1290 -360 1360 -430 {
lab=#net3}
N 1330 -360 1350 -360 {
lab=#net2}
N 1260 -430 1330 -360 {
lab=#net2}
N 1230 -430 1260 -430 {
lab=#net2}
N 1360 -430 1390 -430 {
lab=#net3}
N 1230 -360 1230 -250 {
lab=vss}
N 1390 -360 1390 -250 {
lab=vss}
N 1090 -250 1230 -250 {
lab=vss}
N 1230 -250 1390 -250 {
lab=vss}
N 1390 -250 1530 -250 {
lab=vss}
N 1530 -340 1530 -250 {
lab=vss}
N 1090 -340 1090 -250 {
lab=vss}
N 1610 -390 1610 -340 {
lab=#net3}
N 1530 -390 1610 -390 {
lab=#net3}
N 1530 -430 1530 -390 {
lab=#net3}
N 1570 -340 1610 -340 {
lab=#net3}
N 1830 -340 1830 -250 {
lab=vss}
N 1730 -840 1730 -780 {
lab=#net4}
N 1730 -840 1790 -840 {
lab=#net4}
N 1660 -910 1660 -840 {
lab=vdd}
N 1830 -910 1830 -840 {
lab=vdd}
N 970 -910 1310 -910 {
lab=vdd}
N 970 -250 1090 -250 {
lab=vss}
N 1310 -910 1310 -790 {
lab=vdd}
N 1170 -700 1170 -650 {
lab=#net1}
N 1450 -700 1450 -650 {
lab=#net1}
N 1170 -620 1450 -620 {
lab=vdd}
N 1170 -700 1310 -700 {
lab=#net1}
N 1310 -700 1450 -700 {
lab=#net1}
N 1660 -910 1830 -910 {
lab=vdd}
N 1660 -810 1660 -780 {
lab=#net4}
N 2080 -670 2080 -610 {
lab=cmp_p1}
N 600 -540 650 -540 {
lab=#net5}
N 550 -640 550 -580 {
lab=cmp_p2}
N 550 -640 610 -640 {
lab=cmp_p2}
N 2020 -670 2080 -670 {
lab=cmp_p1}
N 300 -920 300 -900 {
lab=cmp_p1}
N 320 -920 320 -890 {
lab=vss}
N 320 -920 340 -920 {
lab=vss}
N 320 -950 320 -920 {
lab=vss}
N 360 -1030 410 -1030 {
lab=ip}
N 260 -920 300 -920 {
lab=cmp_p1}
N 300 -940 300 -920 {
lab=cmp_p1}
N 90 -1060 90 -950 {
lab=vip}
N 90 -1060 260 -1060 {
lab=vip}
N 180 -1000 180 -890 {
lab=vin}
N 180 -1000 260 -1000 {
lab=vin}
N 70 -950 90 -950 {
lab=vip}
N 180 -890 180 -780 {
lab=vin}
N 360 -810 410 -810 {
lab=in}
N 180 -780 260 -780 {
lab=vin}
N 90 -950 90 -840 {
lab=vip}
N 90 -840 260 -840 {
lab=vip}
N 160 -890 180 -890 {
lab=vin}
N 410 -520 410 -470 {
lab=vss}
N 450 -540 500 -540 {
lab=#net6}
N 410 -470 520 -470 {
lab=vss}
N 2250 -550 2250 -500 {
lab=vss}
N 2250 -500 2340 -500 {
lab=vss}
N 2110 -500 2250 -500 {
lab=vss}
N 1660 -780 1730 -780 {
lab=#net4}
N 1610 -340 1790 -340 {
lab=#net3}
N 1310 -910 1660 -910 {
lab=vdd}
N 1660 -250 1830 -250 {
lab=vss}
N 1660 -780 1660 -510 {
lab=#net4}
N 1660 -480 1660 -250 {
lab=vss}
N 1530 -250 1660 -250 {
lab=vss}
N 1340 -480 1620 -480 {
lab=#net2}
N 1280 -540 1340 -480 {
lab=#net2}
N 1170 -540 1280 -540 {
lab=#net2}
N 1170 -590 1170 -540 {
lab=#net2}
N 1700 -840 1730 -840 {
lab=#net4}
N 790 -340 790 -250 {
lab=vss}
N 900 -840 900 -780 {
lab=#net7}
N 830 -840 900 -840 {
lab=#net7}
N 970 -910 970 -840 {
lab=vdd}
N 790 -910 790 -840 {
lab=vdd}
N 790 -910 970 -910 {
lab=vdd}
N 970 -810 970 -780 {
lab=#net7}
N 790 -540 790 -370 {
lab=#net8}
N 900 -780 970 -780 {
lab=#net7}
N 790 -250 970 -250 {
lab=vss}
N 970 -780 970 -510 {
lab=#net7}
N 970 -480 970 -250 {
lab=vss}
N 900 -840 930 -840 {
lab=#net7}
N 1010 -340 1050 -340 {
lab=#net2}
N 1010 -390 1010 -340 {
lab=#net2}
N 830 -340 1010 -340 {
lab=#net2}
N 1010 -390 1090 -390 {
lab=#net2}
N 1090 -430 1090 -390 {
lab=#net2}
N 1010 -480 1280 -480 {
lab=#net3}
N 1280 -480 1340 -540 {
lab=#net3}
N 1340 -540 1450 -540 {
lab=#net3}
N 1450 -590 1450 -540 {
lab=#net3}
N 730 -540 790 -540 {
lab=#net8}
N 790 -810 790 -540 {
lab=#net8}
N 1830 -570 1830 -370 {
lab=#net9}
N 2130 -570 2220 -570 {
lab=#net10}
N 2110 -520 2110 -500 {
lab=vss}
N 1980 -570 2030 -570 {
lab=#net11}
N 1830 -570 1900 -570 {
lab=#net9}
N 1830 -810 1830 -570 {
lab=#net9}
N 330 -470 410 -470 {
lab=vss}
N 520 -490 520 -470 {
lab=vss}
N 2290 -570 2410 -570 {
lab=vout}
N 250 -540 370 -540 {
lab=vout}
C {devices/ipin.sym} 870 -1040 0 0 {name=p2 lab=vss
}
C {devices/ipin.sym} 870 -1060 0 0 {name=p3 lab=vdd
}
C {JNW_ATR_SKY130A/JNWATR_PCH_12C1F2.sym} 1130 -620 0 0 {name=x1[3:0]}
C {JNW_ATR_SKY130A/JNWATR_PCH_12C1F2.sym} 1490 -620 0 1 {name=x2[3:0]}
C {devices/ipin.sym} 1400 -790 2 0 {name=p1 lab=pbias
}
C {JNW_ATR_SKY130A/JNWATR_PCH_2C1F2.sym} 1350 -790 0 1 {name=x1}
C {devices/ipin.sym} 160 -890 0 0 {name=p5 lab=vin
}
C {devices/ipin.sym} 70 -950 0 0 {name=p6 lab=vip
}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 1050 -340 0 0 {name=x2 }
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 1270 -360 0 1 {name=x3 }
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 1350 -360 0 0 {name=x4 }
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 1570 -340 0 1 {name=x5 }
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 1620 -480 0 0 {name=x6 }
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 1790 -340 0 0 {name=x7 }
C {JNW_ATR_SKY130A/JNWATR_PCH_4C5F0.sym} 1790 -840 0 0 {name=x8 }
C {JNW_ATR_SKY130A/JNWATR_PCH_4C5F0.sym} 1700 -840 0 1 {name=x9 }
C {devices/opin.sym} 2410 -570 2 1 {name=p7 lab=vout}
C {devices/lab_wire.sym} 1330 -620 0 0 {name=p4 sig_type=std_logic lab=vdd}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 1900 -570 0 0 {name=x10 }
C {devices/ipin.sym} 870 -1000 0 0 {name=p10 lab=cmp_p1
}
C {devices/lab_wire.sym} 1940 -610 0 1 {name=p18 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 1940 -530 0 1 {name=p19 sig_type=std_logic lab=vss}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 2020 -570 0 0 {name=x14 }
C {devices/lab_wire.sym} 2110 -610 2 0 {name=p20 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 2110 -520 2 0 {name=p21 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 2080 -670 0 0 {name=p22 sig_type=std_logic lab=cmp_p1}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 730 -540 0 1 {name=x15 }
C {devices/lab_wire.sym} 690 -580 0 0 {name=p23 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 690 -500 0 0 {name=p24 sig_type=std_logic lab=vss}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 610 -540 0 1 {name=x16 }
C {devices/lab_wire.sym} 520 -580 2 1 {name=p25 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 520 -490 2 1 {name=p26 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 550 -640 0 1 {name=p27 sig_type=std_logic lab=cmp_p2}
C {devices/lab_wire.sym} 250 -540 2 1 {name=p28 sig_type=std_logic lab=vout}
C {JNW_AVV_SKY130A/MUX.sym} 310 -1030 0 0 {name=x17}
C {JNW_AVV_SKY130A/MUX.sym} 310 -810 2 1 {name=x18}
C {devices/lab_wire.sym} 340 -920 0 1 {name=p29 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 310 -730 0 1 {name=p30 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 310 -1110 0 1 {name=p31 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 410 -810 0 1 {name=p32 sig_type=std_logic lab=in}
C {devices/lab_wire.sym} 410 -1030 0 1 {name=p33 sig_type=std_logic lab=ip}
C {devices/lab_wire.sym} 1090 -620 0 0 {name=p34 sig_type=std_logic lab=ip}
C {devices/lab_wire.sym} 1530 -620 0 1 {name=p35 sig_type=std_logic lab=in}
C {devices/lab_wire.sym} 260 -920 0 0 {name=p36 sig_type=std_logic lab=cmp_p1}
C {devices/ipin.sym} 870 -1020 0 0 {name=p11 lab=cmp_p2
}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 2340 -560 2 1 {name=x20 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 2290 -570 0 1 {name=x19 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 450 -540 0 1 {name=x12 }
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 330 -530 2 1 {name=x21 }
C {devices/lab_wire.sym} 1330 -910 0 1 {name=p8 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 1290 -250 0 1 {name=p9 sig_type=std_logic lab=vss}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 1010 -480 0 1 {name=x11 }
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 830 -340 0 1 {name=x13 }
C {JNW_ATR_SKY130A/JNWATR_PCH_4C5F0.sym} 830 -840 0 1 {name=x22 }
C {JNW_ATR_SKY130A/JNWATR_PCH_4C5F0.sym} 930 -840 0 0 {name=x23 }
