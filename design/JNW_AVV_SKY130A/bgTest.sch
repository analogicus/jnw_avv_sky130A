v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 870 -120 960 -120 {
lab=nbias}
N 960 -120 960 -100 {
lab=nbias}
N 1180 -210 1180 -180 {
lab=pbias}
N 1090 -180 1180 -180 {
lab=pbias}
N 1090 -240 1090 -180 {
lab=pbias}
N 1090 -240 1140 -240 {
lab=pbias}
N 1180 -300 1180 -240 {
lab=vdd}
N 960 -70 960 -20 {
lab=vss}
N 930 -500 960 -500 {
lab=vdd}
N 1020 -270 1020 -20 {
lab=vss}
N 980 -270 1020 -270 {
lab=vss}
N 1020 -350 1020 -270 {
lab=vss}
N 980 -350 1020 -350 {
lab=vss}
N 1020 -430 1020 -350 {
lab=vss}
N 980 -430 1020 -430 {
lab=vss}
N 960 -500 960 -470 {
lab=vdd}
N 1090 -70 1140 -70 {
lab=nbias}
N 1020 -20 1180 -20 {
lab=vss}
N 1150 -300 1180 -300 {
lab=vdd}
N 870 -120 870 -70 {
lab=nbias}
N 870 -70 920 -70 {
lab=nbias}
N 1180 -70 1180 -20 {
lab=vss}
N 1180 -180 1180 -100 {
lab=pbias}
N 960 -230 960 -120 {
lab=nbias}
N 490 -790 490 -780 {
lab=#net1}
N 500 -800 510 -800 {
lab=#net1}
N 210 -790 210 -780 {
lab=#net2}
N 200 -800 210 -800 {
lab=#net2}
N 510 -790 510 -780 {
lab=#net1}
N 210 -800 210 -790 {
lab=#net2}
N 490 -800 490 -790 {
lab=#net1}
N 390 -790 490 -790 {
lab=#net1}
N 200 -780 210 -780 {
lab=#net2}
N 210 -790 310 -790 {
lab=#net2}
N 190 -790 190 -780 {
lab=#net2}
N 240 -260 240 -210 {
lab=vss}
N 200 -210 240 -210 {
lab=vss}
N 200 -230 200 -210 {
lab=vss}
N 540 -180 540 -130 {
lab=vss}
N 500 -130 540 -130 {
lab=vss}
N 500 -150 500 -130 {
lab=vss}
N 500 -780 510 -780 {
lab=#net1}
N 380 -860 500 -860 {
lab=#net1}
N 200 -860 200 -800 {
lab=#net2}
N 190 -800 200 -800 {
lab=#net2}
N 500 -860 500 -800 {
lab=#net1}
N 490 -800 500 -800 {
lab=#net1}
N 200 -1200 200 -860 {
lab=#net2}
N 200 -860 320 -860 {
lab=#net2}
N 350 -1230 350 -1150 {
lab=vctrl}
N 350 -1230 460 -1230 {
lab=vctrl}
N 240 -1230 350 -1230 {
lab=vctrl}
N 200 -1330 200 -1230 {
lab=vdd}
N 200 -1330 500 -1330 {
lab=vdd}
N 740 -1330 740 -1230 {
lab=vdd}
N 500 -1330 740 -1330 {
lab=vdd}
N 500 -1330 500 -1230 {
lab=vdd}
N 740 -930 740 -740 {
lab=vref}
N 510 -790 570 -790 {
lab=#net1}
N 510 -800 510 -790 {
lab=#net1}
N 130 -790 190 -790 {
lab=#net2}
N 190 -800 190 -790 {
lab=#net2}
N 740 -930 780 -930 {
lab=vref}
N 740 -1200 740 -930 {
lab=vref}
N 570 -1230 700 -1230 {
lab=vctrl}
N 500 -130 500 -20 {
lab=vss}
N 200 -210 200 -20 {
lab=vss}
N 500 -20 740 -20 {
lab=vss}
N 670 -700 720 -700 {
lab=vss}
N 740 -660 740 -20 {
lab=vss}
N 960 -20 1020 -20 {
lab=vss}
N 740 -20 960 -20 {
lab=vss}
N 480 -20 500 -20 {
lab=vss}
N 500 -1200 500 -1130 {
lab=#net3}
N 500 -780 500 -750 {
lab=#net1}
N 490 -780 500 -780 {
lab=#net1}
N 390 -790 390 -750 {
lab=#net1}
N 200 -780 200 -750 {
lab=#net2}
N 190 -780 200 -780 {
lab=#net2}
N 200 -690 200 -290 {
lab=#net4}
N 310 -790 310 -750 {
lab=#net2}
N 1060 -890 1060 -820 {
lab=VBE}
N 1060 -740 1060 -700 {
lab=vss}
N 1060 -700 1120 -700 {
lab=vss}
N 1060 -890 1090 -890 {
lab=VBE}
N 1100 -790 1120 -790 {
lab=vss}
N 1120 -790 1120 -740 {
lab=vss}
N 1060 -740 1120 -740 {
lab=vss}
N 1060 -760 1060 -740 {
lab=vss}
N 1310 -1100 1370 -1100 {
lab=#net5}
N 1310 -1080 1370 -1080 {
lab=#net5}
N 1410 -1150 1410 -1130 {
lab=vdd}
N 1380 -1150 1410 -1150 {
lab=vdd}
N 1410 -1050 1410 -1030 {
lab=vss}
N 1380 -1030 1410 -1030 {
lab=vss}
N 1460 -1090 1510 -1090 {
lab=#net6}
N 500 -520 500 -370 {
lab=#net7}
N 350 -300 370 -300 {
lab=vss}
N 330 -300 350 -300 {
lab=vss}
N 310 -380 310 -340 {
lab=#net8}
N 390 -380 390 -340 {
lab=#net9}
N 350 -420 370 -420 {
lab=vss}
N 330 -420 350 -420 {
lab=vss}
N 350 -420 350 -300 {
lab=vss}
N 350 -580 370 -580 {
lab=vss}
N 350 -580 350 -420 {
lab=vss}
N 330 -580 350 -580 {
lab=vss}
N 390 -540 390 -460 {
lab=#net10}
N 310 -540 310 -460 {
lab=#net11}
N 500 -520 580 -520 {
lab=#net7}
N 500 -600 580 -600 {
lab=#net12}
N 480 -560 560 -560 {
lab=vss}
N 310 -690 310 -620 {
lab=#net13}
N 390 -690 390 -620 {
lab=#net14}
N 500 -690 500 -600 {
lab=#net12}
N 500 -290 500 -210 {
lab=#net15}
N 480 -560 480 -20 {
lab=vss}
N 390 -20 480 -20 {
lab=vss}
N 350 -300 350 -20 {
lab=vss}
N 310 -260 310 -20 {
lab=vss}
N 200 -20 310 -20 {
lab=vss}
N 390 -260 390 -20 {
lab=vss}
N 350 -20 390 -20 {
lab=vss}
N 310 -20 350 -20 {
lab=vss}
N 500 -1070 500 -860 {
lab=#net1}
N 320 -860 380 -890 {
lab=#net2}
N 320 -890 380 -860 {
lab=#net1}
N 250 -1050 250 -1000 {
lab=vdd}
N 250 -1050 290 -1050 {
lab=vdd}
N 450 -1050 450 -1000 {
lab=vss}
N 410 -1050 450 -1050 {
lab=vss}
N 940 -1450 980 -1450 {
lab=y}
N 890 -1530 890 -1490 {
lab=vss}
N 910 -1530 910 -1490 {
lab=B}
N 850 -1450 880 -1450 {
lab=#net16}
N 980 -1390 1050 -1390 {
lab=vss}
N 1690 -760 1690 -690 {
lab=#net17}
N 1690 -690 1850 -690 {
lab=#net17}
N 1690 -910 1840 -910 {
lab=#net18}
N 1690 -910 1690 -840 {
lab=#net18}
N 1600 -910 1690 -910 {
lab=#net18}
N 1940 -750 2020 -750 {
lab=#net19}
N 2310 -790 2310 -750 {
lab=#net20}
N 1840 -790 2310 -790 {
lab=#net20}
N 1840 -890 1840 -790 {
lab=#net20}
N 1930 -900 1990 -900 {
lab=#net21}
N 2300 -900 2300 -760 {
lab=#net22}
N 1850 -760 2300 -760 {
lab=#net22}
N 1850 -760 1850 -710 {
lab=#net22}
N 1310 -1100 1310 -1080 {
lab=#net5}
N 2300 -900 2320 -900 {
lab=#net22}
N 2060 -730 2060 -680 {
lab=vss}
N 2100 -750 2310 -750 {
lab=#net20}
N 2060 -680 2210 -680 {
lab=vss}
N 2030 -880 2030 -830 {
lab=vss}
N 2070 -900 2300 -900 {
lab=#net22}
N 2030 -830 2180 -830 {
lab=vss}
N 2310 -750 2330 -700 {
lab=#net20}
N 2400 -900 2560 -900 {
lab=clk1}
N 2490 -700 2530 -700 {
lab=clk2}
N 2450 -660 2450 -630 {
lab=vss}
N 2450 -630 2510 -630 {
lab=vss}
N 2360 -860 2360 -830 {
lab=vss}
N 2360 -830 2480 -830 {
lab=vss}
N 3200 -440 3330 -440 {
lab=nbias}
N 3200 -440 3200 -380 {
lab=nbias}
N 3490 -730 3490 -700 {
lab=pbias}
N 3400 -700 3490 -700 {
lab=pbias}
N 3400 -760 3400 -700 {
lab=pbias}
N 3400 -760 3450 -760 {
lab=pbias}
N 3490 -820 3490 -760 {
lab=vdd}
N 3200 -350 3200 -300 {
lab=vss}
N 3140 -740 3140 -300 {
lab=vss}
N 3140 -300 3200 -300 {
lab=vss}
N 3140 -740 3180 -740 {
lab=vss}
N 3330 -440 3330 -350 {
lab=nbias}
N 3490 -350 3490 -300 {
lab=vss}
N 3330 -350 3450 -350 {
lab=nbias}
N 3200 -620 3200 -440 {
lab=nbias}
N 3490 -700 3490 -550 {
lab=pbias}
N 3490 -490 3490 -380 {
lab=#net23}
N 3140 -900 3180 -900 {
lab=vss}
N 3200 -1140 3200 -1100 {
lab=vdd}
N 3200 -690 3200 -680 {
lab=tg_bot}
N 3140 -1060 3330 -1060 {
lab=vss}
N 3140 -980 3140 -900 {
lab=vss}
N 3200 -1100 3350 -1100 {
lab=vdd}
N 3140 -820 3140 -740 {
lab=vss}
N 3200 -300 3490 -300 {
lab=vss}
N 3350 -800 3350 -690 {
lab=tg_bot}
N 3200 -690 3350 -690 {
lab=tg_bot}
N 3200 -700 3200 -690 {
lab=tg_bot}
N 3350 -1020 3350 -900 {
lab=tg_top}
N 3140 -980 3180 -980 {
lab=vss}
N 3140 -1060 3140 -980 {
lab=vss}
N 3240 -350 3330 -350 {
lab=nbias}
N 3390 -820 3490 -820 {
lab=vdd}
N 3390 -850 3450 -850 {
lab=vss}
N 3140 -820 3180 -820 {
lab=vss}
N 3140 -900 3140 -820 {
lab=vss}
N 3640 -820 3640 -770 {
lab=vdd}
N 3490 -820 3640 -820 {
lab=vdd}
N 3640 -740 3640 -700 {
lab=#net24}
N 3640 -350 3640 -300 {
lab=vss}
N 3490 -300 3640 -300 {
lab=vss}
N 3550 -350 3600 -350 {
lab=nbias}
N 3640 -480 3640 -380 {
lab=VCP}
N 3660 -560 3680 -560 {
lab=vss}
N 3680 -560 3680 -300 {
lab=vss}
N 3640 -300 3680 -300 {
lab=vss}
N 3640 -520 3640 -480 {
lab=VCP}
N 3640 -620 3640 -600 {
lab=VBP}
N 3640 -670 3670 -670 {
lab=vdd}
N 3670 -820 3670 -670 {
lab=vdd}
N 3640 -820 3670 -820 {
lab=vdd}
N 3600 -670 3600 -480 {
lab=VCP}
N 3600 -480 3640 -480 {
lab=VCP}
N 3580 -770 3600 -770 {
lab=VBP}
N 3580 -770 3580 -620 {
lab=VBP}
N 3580 -620 3640 -620 {
lab=VBP}
N 3640 -640 3640 -620 {
lab=VBP}
N 4360 -410 4360 -360 {
lab=#net25}
N 4320 -360 4360 -360 {
lab=#net25}
N 4320 -380 4320 -360 {
lab=#net25}
N 4320 -700 4320 -610 {
lab=#net26}
N 4320 -530 4320 -440 {
lab=VbeBD}
N 4360 -890 4420 -890 {
lab=bd}
N 4360 -860 4400 -860 {
lab=vdd}
N 4320 -840 4320 -780 {
lab=vpm}
N 4320 -1070 4320 -1010 {
lab=vdd}
N 4220 -1010 4280 -1010 {
lab=B}
N 4200 -550 4200 -500 {
lab=#net27}
N 4200 -680 4200 -630 {
lab=#net28}
N 4200 -780 4200 -760 {
lab=vpm}
N 4200 -780 4320 -780 {
lab=vpm}
N 4240 -160 4300 -160 {
lab=vss}
N 4240 -460 4240 -160 {
lab=vss}
N 4240 -590 4240 -460 {
lab=vss}
N 4240 -720 4240 -590 {
lab=vss}
N 4200 -160 4240 -160 {
lab=vss}
N 5810 -330 5810 -210 {
lab=vss}
N 5770 -380 5770 -330 {
lab=vss}
N 5770 -330 5810 -330 {
lab=vss}
N 5810 -350 5810 -330 {
lab=vss}
N 5810 -750 5810 -410 {
lab=vn}
N 5810 -750 5910 -750 {
lab=vn}
N 5950 -830 6010 -830 {
lab=A}
N 5950 -800 5990 -800 {
lab=vdd}
N 5910 -1010 5910 -880 {
lab=#net29}
N 5910 -1100 5910 -1040 {
lab=vdd}
N 5910 -1100 5960 -1100 {
lab=vdd}
N 5810 -1040 5870 -1040 {
lab=B}
N 5910 -780 5910 -750 {
lab=vn}
N 4320 -980 4320 -940 {
lab=#net30}
N 4200 -420 4200 -380 {
lab=#net31}
N 4320 -160 4410 -160 {
lab=vss}
N 4320 -360 4320 -340 {
lab=#net25}
N 4320 -1070 4370 -1070 {
lab=vdd}
N 4300 -570 4300 -160 {
lab=vss}
N 5860 -410 5860 -210 {
lab=vss}
N 5860 -540 5860 -490 {
lab=#net32}
N 5860 -670 5860 -620 {
lab=#net33}
N 5810 -210 5860 -210 {
lab=vss}
N 4300 -740 4430 -740 {
lab=vss}
N 5880 -710 5880 -210 {
lab=vss}
N 5880 -210 5970 -210 {
lab=vss}
N 5860 -210 5880 -210 {
lab=vss}
N 1060 -930 1060 -890 {
lab=VBE}
N 4170 -720 4240 -720 {
lab=vss}
N 4170 -590 4240 -590 {
lab=vss}
N 4170 -460 4240 -460 {
lab=vss}
N 4300 -570 4340 -570 {
lab=vss}
N 4300 -740 4300 -570 {
lab=vss}
N 4320 -700 4400 -700 {
lab=#net26}
N 1940 -750 1940 -700 {
lab=#net19}
N 4200 -320 4200 -270 {
lab=#net34}
N 4200 -240 4200 -160 {
lab=vss}
N 4120 -240 4160 -240 {
lab=bd}
N 5300 -410 5300 -360 {
lab=#net35}
N 5260 -360 5300 -360 {
lab=#net35}
N 5260 -380 5260 -360 {
lab=#net35}
N 5260 -700 5260 -610 {
lab=#net36}
N 5260 -530 5260 -440 {
lab=#net37}
N 5300 -890 5360 -890 {
lab=A}
N 5300 -860 5340 -860 {
lab=vdd}
N 5260 -840 5260 -780 {
lab=#net38}
N 5260 -1070 5260 -1010 {
lab=vdd}
N 5160 -1010 5220 -1010 {
lab=B}
N 5260 -160 5350 -160 {
lab=vss}
N 5140 -550 5140 -500 {
lab=#net39}
N 5140 -680 5140 -630 {
lab=#net40}
N 5140 -780 5140 -760 {
lab=#net38}
N 5140 -780 5260 -780 {
lab=#net38}
N 5180 -160 5240 -160 {
lab=vss}
N 5180 -460 5180 -160 {
lab=vss}
N 5180 -590 5180 -460 {
lab=vss}
N 5180 -720 5180 -590 {
lab=vss}
N 5140 -160 5180 -160 {
lab=vss}
N 5260 -980 5260 -940 {
lab=#net41}
N 5140 -420 5140 -380 {
lab=#net42}
N 5260 -280 5260 -160 {
lab=vss}
N 5240 -160 5260 -160 {
lab=vss}
N 5260 -360 5260 -340 {
lab=#net35}
N 5290 -1070 5290 -1010 {
lab=vdd}
N 5290 -1070 5310 -1070 {
lab=vdd}
N 5260 -1070 5290 -1070 {
lab=vdd}
N 5260 -980 5290 -980 {
lab=#net41}
N 5240 -570 5240 -160 {
lab=vss}
N 5240 -740 5440 -740 {
lab=vss}
N 5090 -550 5090 -500 {
lab=#net43}
N 5090 -680 5090 -630 {
lab=#net44}
N 5090 -780 5090 -760 {
lab=#net45}
N 5050 -780 5090 -780 {
lab=#net45}
N 5110 -720 5180 -720 {
lab=vss}
N 5110 -590 5180 -590 {
lab=vss}
N 5110 -460 5180 -460 {
lab=vss}
N 5240 -570 5280 -570 {
lab=vss}
N 5240 -740 5240 -570 {
lab=vss}
N 5260 -780 5480 -780 {
lab=#net38}
N 5260 -700 5340 -700 {
lab=#net36}
N 5140 -320 5140 -160 {
lab=vss}
N 4320 -280 4320 -160 {
lab=vss}
N 4300 -160 4320 -160 {
lab=vss}
N 4320 -780 4540 -780 {
lab=vpm}
N 4590 -880 4590 -820 {
lab=bdm}
N 4620 -860 4620 -820 {
lab=vdd}
N 4670 -780 4690 -780 {
lab=vp}
N 4670 -780 4670 -610 {
lab=vp}
N 4640 -780 4670 -780 {
lab=vp}
N 4670 -540 4670 -440 {}
C {devices/ipin.sym} 120 -1010 0 0 {name=p4 lab=vss}
C {devices/ipin.sym} 120 -1040 0 0 {name=p5 lab=vdd}
C {devices/lab_wire.sym} 1140 -180 0 0 {name=p32 sig_type=std_logic lab=pbias}
C {devices/lab_wire.sym} 960 -500 0 0 {name=p34 sig_type=std_logic lab=vdd}
C {JNW_ATR_SKY130A/JNWATR_PCH_8C5F0.sym} 1140 -240 0 0 {name=x7 }
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 920 -70 0 0 {name=x28 }
C {devices/lab_wire.sym} 930 -120 0 0 {name=p12 sig_type=std_logic lab=nbias}
C {devices/lab_wire.sym} 1180 -300 0 0 {name=p13 sig_type=std_logic lab=vdd}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 1140 -70 0 0 {name=x4 }
C {devices/lab_wire.sym} 1130 -70 0 0 {name=p14 sig_type=std_logic lab=nbias}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 960 -230 3 0 {name=x26 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 960 -310 3 0 {name=x27 }
C {JNW_TR_SKY130A/JNWTR_RPPO8.sym} 960 -390 3 0 {name=x11 }
C {sky130_fd_pr/pnp_05v5.sym} 520 -180 0 1 {name=Q1
model=pnp_05v5_W3p40L3p40
m=8
spiceprefix=X
}
C {sky130_fd_pr/pnp_05v5.sym} 220 -260 0 1 {name=Q2
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {devices/lab_wire.sym} 340 -1330 0 1 {name=p29 sig_type=std_logic lab=vdd

}
C {devices/opin.sym} 5810 -750 2 0 {name=p44 lab=vn}
C {JNW_ATR_SKY130A/JNWATR_PCH_4C1F2.sym} 460 -1230 0 0 {name=x2 }
C {JNW_ATR_SKY130A/JNWATR_PCH_4C1F2.sym} 240 -1230 0 1 {name=x3 }
C {JNW_ATR_SKY130A/JNWATR_PCH_4C1F2.sym} 700 -1230 0 0 {name=x5 }
C {devices/lab_wire.sym} 340 -1230 0 1 {name=p8 sig_type=std_logic lab=vctrl

}
C {devices/lab_wire.sym} 620 -1230 0 1 {name=p9 sig_type=std_logic lab=vctrl

}
C {devices/lab_wire.sym} 620 -20 0 0 {name=p3 sig_type=std_logic lab=vss
}
C {devices/opin.sym} 4690 -780 0 0 {name=p7 lab=vp}
C {devices/opin.sym} 780 -930 0 0 {name=p10 lab=vref}
C {devices/lab_wire.sym} 700 -700 0 0 {name=p11 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 740 -740 1 0 {name=x6 }
C {devices/vsource.sym} 500 -1100 0 0 {name=v_itot1 value=0 savecurrent=true}
C {devices/vsource.sym} 500 -720 0 0 {name=v_ip1 value=0 savecurrent=true}
C {devices/vsource.sym} 390 -720 0 0 {name=v_ip2 value=0 savecurrent=true}
C {devices/vsource.sym} 200 -720 0 0 {name=v_in1 value=0 savecurrent=true}
C {devices/vsource.sym} 310 -720 0 0 {name=v_in2 value=0 savecurrent=true}
C {devices/isource.sym} 1060 -960 0 0 {name=IVBE value=3.5u}
C {devices/lab_wire.sym} 1110 -700 0 0 {name=p16 sig_type=std_logic lab=vss
}
C {devices/opin.sym} 1090 -890 0 0 {name=p17 lab=VBE}
C {sky130_fd_pr/pnp_05v5.sym} 1080 -790 0 1 {name=Q3
model=pnp_05v5_W3p40L3p40
m=8
spiceprefix=X
}
C {JNW_AVV_SKY130A/xor.sym} 1410 -1090 0 0 {name=x16}
C {devices/lab_wire.sym} 1410 -1150 0 0 {name=p20 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 1410 -1030 0 0 {name=p21 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 500 -370 1 0 {name=x18 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 390 -340 1 0 {name=x8 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 310 -340 3 1 {name=x20 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 540 -600 1 0 {name=x9 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 500 -600 1 0 {name=x14 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 580 -600 1 0 {name=x10 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 310 -460 3 1 {name=x12 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 390 -460 1 0 {name=x19 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 390 -620 1 0 {name=x21 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 310 -540 3 0 {name=x22 }
C {JNW_AVV_SKY130A/OTA.sym} 350 -1000 3 0 {name=x1}
C {devices/lab_wire.sym} 260 -1050 0 1 {name=p1 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 440 -1050 0 0 {name=p2 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 890 -1520 0 0 {name=p6 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 910 -1530 0 0 {name=p24 sig_type=std_logic lab=B
}
C {devices/lab_wire.sym} 970 -1450 0 0 {name=p25 sig_type=std_logic lab=y
}
C {devices/switch_v_xyce.sym} 910 -1450 1 0 {.MODEL SWITCH1 SW(VT=0.5 VH=0.01 RON=0.01 ROFF=10000000)

name=S1 model=SWITCH1 state=OFF

}
C {devices/netlist.sym} 900 -1300 0 0 {name=s2 value=".MODEL SWITCH1 SW(VT=0.9 RON=1 ROFF=1000000000)"
}
C {devices/res.sym} 980 -1420 0 0 {name=R1
value=1k
footprint=1206
device=resistor
m=1}
C {devices/lab_wire.sym} 1040 -1390 0 0 {name=p22 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_NDX1_CV.sym} 1850 -690 0 0 {name=x13 }
C {devices/lab_wire.sym} 1890 -740 0 0 {name=p26 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 1890 -660 0 0 {name=p27 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_NDX1_CV.sym} 1840 -890 0 0 {name=x15 }
C {devices/lab_wire.sym} 1880 -940 0 0 {name=p28 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 1880 -860 0 0 {name=p30 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 1690 -840 1 0 {name=x17 }
C {devices/lab_wire.sym} 1650 -800 0 0 {name=p31 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 1730 -800 0 0 {name=p33 sig_type=std_logic lab=vdd}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 1970 -1070 0 0 {name=x23 }
C {devices/lab_wire.sym} 2010 -1030 3 0 {name=p36 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 2010 -1110 3 0 {name=p37 sig_type=std_logic lab=vdd}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 2050 -1070 0 0 {name=x24 }
C {devices/lab_wire.sym} 2090 -1030 3 0 {name=p38 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 2090 -1110 3 0 {name=p39 sig_type=std_logic lab=vdd}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 2130 -1070 0 0 {name=x25 }
C {devices/lab_wire.sym} 2170 -1030 3 0 {name=p40 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 2170 -1110 3 0 {name=p41 sig_type=std_logic lab=vdd}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 2210 -1070 0 0 {name=x29 }
C {devices/lab_wire.sym} 2250 -1030 3 0 {name=p42 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 2250 -1110 3 0 {name=p43 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 2560 -900 0 0 {name=p53 sig_type=std_logic lab=clk1}
C {devices/lab_wire.sym} 2530 -700 0 0 {name=p54 sig_type=std_logic lab=clk2}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 2320 -900 0 0 {name=x34 }
C {devices/lab_wire.sym} 2360 -860 3 0 {name=p19 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 2360 -940 3 0 {name=p23 sig_type=std_logic lab=vdd}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 2210 -690 0 0 {name=x1[3:0]}
C {devices/lab_wire.sym} 2110 -680 3 0 {name=p45 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 2180 -840 0 0 {name=x2[3:0]}
C {devices/lab_wire.sym} 2080 -830 3 0 {name=p46 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 2330 -700 0 0 {name=x32 }
C {devices/lab_wire.sym} 2370 -660 3 0 {name=p47 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 2370 -740 3 0 {name=p48 sig_type=std_logic lab=vdd}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 2410 -700 0 0 {name=x35 }
C {devices/lab_wire.sym} 2450 -660 3 0 {name=p51 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 2450 -740 3 0 {name=p52 sig_type=std_logic lab=vdd}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 2480 -840 0 0 {name=x3[2:0]}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 2510 -640 0 0 {name=x4[2:0]}
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 2020 -750 0 0 {name=x31 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 1990 -900 0 0 {name=x30 }
C {devices/lab_wire.sym} 3450 -700 0 0 {name=p49 sig_type=std_logic lab=pbias}
C {devices/lab_wire.sym} 3200 -1140 0 1 {name=p50 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 3370 -300 0 1 {name=p55 sig_type=std_logic lab=vss}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 3240 -350 0 1 {name=x33 }
C {devices/lab_wire.sym} 3490 -820 0 0 {name=p56 sig_type=std_logic lab=vdd}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 3450 -350 0 0 {name=x36 }
C {devices/lab_wire.sym} 3430 -350 0 0 {name=p57 sig_type=std_logic lab=nbias}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 3200 -700 1 1 {name=x37 }
C {devices/vsource.sym} 3200 -650 0 0 {name=v_nbias1 value=0 savecurrent=true}
C {devices/vsource.sym} 3490 -520 0 0 {name=v_pbias1 value=0 savecurrent=true}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 3200 -780 1 1 {name=x38 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 3200 -860 1 1 {name=x39 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 3200 -940 1 1 {name=x40 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 3200 -1020 1 1 {name=x41 }
C {JNW_ATR_SKY130A/JNWATR_PCH_2C5F0.sym} 3450 -760 0 0 {name=x42 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 3350 -1020 1 1 {name=x43 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 3350 -910 1 0 {name=x44 }
C {devices/lab_wire.sym} 3350 -930 0 1 {name=p63 sig_type=std_logic lab=tg_top}
C {devices/lab_wire.sym} 3350 -765 0 1 {name=p64 sig_type=std_logic lab=tg_bot}
C {devices/lab_wire.sym} 3300 -820 0 1 {name=p65 sig_type=std_logic lab=vss}
C {JNW_ATR_SKY130A/JNWATR_PCH_2C5F0.sym} 3600 -770 0 0 {name=x45 }
C {JNW_ATR_SKY130A/JNWATR_PCH_8C1F2.sym} 3600 -670 0 0 {name=x46 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 3640 -520 3 0 {name=x47 }
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 3600 -350 0 0 {name=x48 }
C {devices/lab_wire.sym} 3590 -350 0 0 {name=p66 sig_type=std_logic lab=nbias}
C {devices/lab_wire.sym} 3580 -670 0 0 {name=p67 sig_type=std_logic lab=VBP}
C {devices/lab_wire.sym} 3600 -560 0 0 {name=p68 sig_type=std_logic lab=VCP}
C {devices/lab_wire.sym} 3430 -850 0 1 {name=p58 sig_type=std_logic lab=vss}
C {sky130_fd_pr/pnp_05v5.sym} 4340 -410 0 1 {name=Q4
model=pnp_05v5_W3p40L3p40
m=8
spiceprefix=X
}
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 4320 -610 1 0 {name=x49 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 4360 -780 1 0 {name=x50 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 4320 -780 1 0 {name=x51 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 4400 -780 1 0 {name=x52 }
C {devices/lab_wire.sym} 4320 -470 0 1 {name=p59 sig_type=std_logic lab=VbeBD

}
C {JNW_ATR_SKY130A/JNWATR_PCH_4C5F0.sym} 4280 -1010 0 0 {name=x53 }
C {devices/lab_wire.sym} 4270 -860 0 0 {name=p60 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 4400 -860 0 0 {name=p61 sig_type=std_logic lab=vdd

}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 4320 -950 1 0 {name=x54 }
C {devices/lab_wire.sym} 4360 -1070 0 0 {name=p69 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 4370 -160 0 1 {name=p70 sig_type=std_logic lab=vss}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 4200 -500 3 1 {name=x55 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 4200 -630 3 1 {name=x56 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 4200 -760 3 1 {name=x57 }
C {sky130_fd_pr/pnp_05v5.sym} 5790 -380 0 0 {name=Q5
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {devices/lab_wire.sym} 5940 -210 0 1 {name=p71 sig_type=std_logic lab=vss}
C {JNW_ATR_SKY130A/JNWATR_PCH_4C5F0.sym} 5870 -1040 0 0 {name=x61 }
C {devices/lab_wire.sym} 5860 -800 0 0 {name=p74 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 5990 -800 0 0 {name=p75 sig_type=std_logic lab=vdd

}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 5910 -890 1 0 {name=x62 }
C {devices/lab_wire.sym} 5950 -1100 0 0 {name=p76 sig_type=std_logic lab=vdd

}
C {devices/ipin.sym} 4610 -1060 0 0 {name=p18 lab=A}
C {devices/ipin.sym} 4220 -1010 0 0 {name=p35 lab=B}
C {devices/vsource.sym} 4320 -310 0 0 {name=vibigdiodebot value=0 savecurrent=true}
C {devices/vsource.sym} 4200 -350 0 0 {name=vibigdioderes value=0 savecurrent=true}
C {devices/lab_wire.sym} 5820 -1040 0 1 {name=p72 sig_type=std_logic lab=B

}
C {devices/lab_wire.sym} 5990 -830 0 1 {name=p73 sig_type=std_logic lab=A

}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 5860 -490 3 1 {name=x71 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 5860 -620 3 1 {name=x72 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 5860 -670 3 0 {name=x73 }
C {devices/lab_wire.sym} 1060 -990 0 0 {name=p15 sig_type=std_logic lab=vdd}
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 4360 -610 1 0 {name=x66 }
C {JNW_ATR_SKY130A/JNWATR_NCH_2C1F2.sym} 4160 -240 0 0 {name=x58 }
C {sky130_fd_pr/pnp_05v5.sym} 5280 -410 0 1 {name=Q6
model=pnp_05v5_W3p40L3p40
m=8
spiceprefix=X
}
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 5260 -610 1 0 {name=x59 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 5300 -780 1 0 {name=x60 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 5260 -780 1 0 {name=x67 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 5340 -780 1 0 {name=x68 }
C {JNW_ATR_SKY130A/JNWATR_PCH_4C5F0.sym} 5220 -1010 0 0 {name=x69 }
C {devices/lab_wire.sym} 5210 -860 0 0 {name=p79 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 5340 -860 0 0 {name=p80 sig_type=std_logic lab=vdd

}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 5260 -950 1 0 {name=x70 }
C {devices/lab_wire.sym} 5300 -1070 0 0 {name=p81 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 5310 -160 0 1 {name=p82 sig_type=std_logic lab=vss}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 5140 -500 3 1 {name=x74 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 5140 -630 3 1 {name=x75 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 5140 -760 3 1 {name=x76 }
C {devices/vsource.sym} 5260 -310 0 0 {name=vibigdiodebot1 value=0 savecurrent=true}
C {devices/vsource.sym} 5140 -350 0 0 {name=vibigdioderes1 value=0 savecurrent=true}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 5090 -500 3 1 {name=x77 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 5090 -630 3 1 {name=x78 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 5090 -760 3 1 {name=x79 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 5300 -610 1 0 {name=x80 }
C {devices/lab_wire.sym} 5350 -890 0 1 {name=p77 sig_type=std_logic lab=A
}
C {devices/lab_wire.sym} 5160 -1010 0 1 {name=p78 sig_type=std_logic lab=B

}
C {JNW_AVV_SKY130A/NonOverlap.sym} 4760 -1060 0 0 {name=x63}
C {devices/lab_wire.sym} 4610 -1080 0 0 {name=p83 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 4610 -1040 2 1 {name=p84 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 4910 -1080 0 1 {name=p85 sig_type=std_logic lab=bd

}
C {devices/lab_wire.sym} 4910 -1040 0 1 {name=p86 sig_type=std_logic lab=bdm
}
C {devices/lab_wire.sym} 4620 -730 3 0 {name=p87 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 4620 -860 3 0 {name=p88 sig_type=std_logic lab=vdd

}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 4530 -780 0 0 {name=x64 }
C {devices/lab_wire.sym} 4450 -780 0 1 {name=p89 sig_type=std_logic lab=vpm
}
C {devices/lab_wire.sym} 4400 -890 0 1 {name=p90 sig_type=std_logic lab=bd

}
C {devices/lab_wire.sym} 4140 -240 0 0 {name=p62 sig_type=std_logic lab=bd

}
C {devices/lab_wire.sym} 4590 -880 0 1 {name=p91 sig_type=std_logic lab=bdm
}
C {JNW_TR_SKY130A/JNWTR_CAPX4.sym} 4670 -550 0 0 {name=x14[10:0]}
C {devices/lab_wire.sym} 4670 -440 0 1 {name=p92 sig_type=std_logic lab=vss}
