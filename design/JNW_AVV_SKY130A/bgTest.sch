v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 870 -120 960 -120 {
lab=nbias}
N 960 -120 960 -100 {
lab=nbias}
N 1180 -210 1180 -180 {
lab=pbias}
N 1090 -180 1180 -180 {
lab=pbias}
N 1090 -240 1090 -180 {
lab=pbias}
N 1090 -240 1140 -240 {
lab=pbias}
N 1180 -300 1180 -240 {
lab=vdd}
N 960 -70 960 -20 {
lab=vss}
N 930 -500 960 -500 {
lab=vdd}
N 1020 -270 1020 -20 {
lab=vss}
N 980 -270 1020 -270 {
lab=vss}
N 1020 -350 1020 -270 {
lab=vss}
N 980 -350 1020 -350 {
lab=vss}
N 1020 -430 1020 -350 {
lab=vss}
N 980 -430 1020 -430 {
lab=vss}
N 960 -500 960 -470 {
lab=vdd}
N 1090 -70 1140 -70 {
lab=nbias}
N 1020 -20 1180 -20 {
lab=vss}
N 1150 -300 1180 -300 {
lab=vdd}
N 870 -120 870 -70 {
lab=nbias}
N 870 -70 920 -70 {
lab=nbias}
N 1180 -70 1180 -20 {
lab=vss}
N 1180 -180 1180 -100 {
lab=pbias}
N 960 -230 960 -120 {
lab=nbias}
N 490 -790 490 -780 {
lab=vp}
N 500 -800 510 -800 {
lab=vp}
N 210 -790 210 -780 {
lab=vn}
N 200 -800 210 -800 {
lab=vn}
N 510 -790 510 -780 {
lab=vp}
N 210 -800 210 -790 {
lab=vn}
N 490 -800 490 -790 {
lab=vp}
N 390 -790 490 -790 {
lab=vp}
N 200 -780 210 -780 {
lab=vn}
N 210 -790 310 -790 {
lab=vn}
N 190 -790 190 -780 {
lab=vn}
N 240 -260 240 -210 {
lab=vss}
N 200 -210 240 -210 {
lab=vss}
N 200 -230 200 -210 {
lab=vss}
N 540 -180 540 -130 {
lab=vss}
N 500 -130 540 -130 {
lab=vss}
N 500 -150 500 -130 {
lab=vss}
N 500 -780 510 -780 {
lab=vp}
N 380 -860 500 -860 {
lab=vp}
N 200 -860 200 -800 {
lab=vn}
N 190 -800 200 -800 {
lab=vn}
N 500 -860 500 -800 {
lab=vp}
N 490 -800 500 -800 {
lab=vp}
N 200 -1200 200 -860 {
lab=vn}
N 200 -860 320 -860 {
lab=vn}
N 350 -1230 350 -1150 {
lab=vctrl}
N 350 -1230 460 -1230 {
lab=vctrl}
N 240 -1230 350 -1230 {
lab=vctrl}
N 200 -1330 200 -1230 {
lab=vdd}
N 200 -1330 500 -1330 {
lab=vdd}
N 740 -1330 740 -1230 {
lab=vdd}
N 500 -1330 740 -1330 {
lab=vdd}
N 500 -1330 500 -1230 {
lab=vdd}
N 740 -930 740 -740 {
lab=vref}
N 510 -790 570 -790 {
lab=vp}
N 510 -800 510 -790 {
lab=vp}
N 130 -790 190 -790 {
lab=vn}
N 190 -800 190 -790 {
lab=vn}
N 740 -930 780 -930 {
lab=vref}
N 740 -1200 740 -930 {
lab=vref}
N 570 -1230 700 -1230 {
lab=vctrl}
N 500 -130 500 -20 {
lab=vss}
N 200 -210 200 -20 {
lab=vss}
N 500 -20 740 -20 {
lab=vss}
N 670 -700 720 -700 {
lab=vss}
N 740 -660 740 -20 {
lab=vss}
N 960 -20 1020 -20 {
lab=vss}
N 740 -20 960 -20 {
lab=vss}
N 480 -20 500 -20 {
lab=vss}
N 500 -1200 500 -1130 {
lab=#net1}
N 500 -780 500 -750 {
lab=vp}
N 490 -780 500 -780 {
lab=vp}
N 390 -790 390 -750 {
lab=vp}
N 200 -780 200 -750 {
lab=vn}
N 190 -780 200 -780 {
lab=vn}
N 200 -690 200 -290 {
lab=#net2}
N 310 -790 310 -750 {
lab=vn}
N 1060 -890 1060 -820 {
lab=VBE}
N 1060 -740 1060 -700 {
lab=vss}
N 1060 -700 1120 -700 {
lab=vss}
N 1060 -1030 1060 -1000 {
lab=vdd}
N 1060 -1030 1110 -1030 {
lab=vdd}
N 1060 -890 1090 -890 {
lab=VBE}
N 1060 -940 1060 -890 {
lab=VBE}
N 1100 -790 1120 -790 {
lab=vss}
N 1120 -790 1120 -740 {
lab=vss}
N 1060 -740 1120 -740 {
lab=vss}
N 1060 -760 1060 -740 {
lab=vss}
N 1310 -1100 1370 -1100 {
lab=B}
N 1310 -1080 1370 -1080 {
lab=B}
N 1410 -1150 1410 -1130 {
lab=vdd}
N 1380 -1150 1410 -1150 {
lab=vdd}
N 1410 -1050 1410 -1030 {
lab=vss}
N 1380 -1030 1410 -1030 {
lab=vss}
N 1460 -1090 1510 -1090 {
lab=#net3}
N 500 -520 500 -370 {
lab=#net4}
N 350 -300 370 -300 {
lab=vss}
N 330 -300 350 -300 {
lab=vss}
N 350 -420 370 -420 {
lab=vss}
N 330 -420 350 -420 {
lab=vss}
N 350 -420 350 -300 {
lab=vss}
N 350 -580 350 -420 {
lab=vss}
N 500 -520 580 -520 {
lab=#net4}
N 500 -600 580 -600 {
lab=#net4}
N 310 -690 310 -460 {
lab=#net5}
N 390 -690 390 -460 {
lab=#net6}
N 500 -690 500 -600 {
lab=#net4}
N 500 -290 500 -210 {
lab=#net7}
N 480 -330 480 -20 {
lab=vss}
N 390 -20 480 -20 {
lab=vss}
N 350 -300 350 -20 {
lab=vss}
N 310 -260 310 -20 {
lab=vss}
N 200 -20 310 -20 {
lab=vss}
N 390 -260 390 -20 {
lab=vss}
N 350 -20 390 -20 {
lab=vss}
N 310 -20 350 -20 {
lab=vss}
N 500 -1070 500 -860 {
lab=vp}
N 320 -860 380 -890 {
lab=vn}
N 320 -890 380 -860 {
lab=vp}
N 250 -1050 250 -1000 {
lab=vdd}
N 250 -1050 290 -1050 {
lab=vdd}
N 450 -1050 450 -1000 {
lab=vss}
N 410 -1050 450 -1050 {
lab=vss}
N 940 -1450 980 -1450 {
lab=y}
N 890 -1530 890 -1490 {
lab=vss}
N 910 -1530 910 -1490 {
lab=B}
N 850 -1450 880 -1450 {
lab=#net8}
N 980 -1390 1050 -1390 {
lab=vss}
N 1690 -760 1690 -690 {
lab=#net9}
N 1690 -690 1850 -690 {
lab=#net9}
N 1690 -910 1840 -910 {
lab=A}
N 1690 -910 1690 -840 {
lab=A}
N 1600 -910 1690 -910 {
lab=A}
N 1940 -700 2020 -700 {
lab=#net10}
N 2310 -790 2310 -700 {
lab=#net11}
N 1840 -790 2310 -790 {
lab=#net11}
N 1840 -890 1840 -790 {
lab=#net11}
N 1930 -900 1990 -900 {
lab=#net12}
N 2300 -900 2300 -760 {
lab=#net13}
N 1850 -760 2300 -760 {
lab=#net13}
N 1850 -760 1850 -710 {
lab=#net13}
N 1310 -1100 1310 -1080 {
lab=B}
N 2300 -900 2320 -900 {
lab=#net13}
N 2060 -680 2060 -630 {
lab=vss}
N 2100 -700 2310 -700 {
lab=#net11}
N 2060 -630 2210 -630 {
lab=vss}
N 2030 -880 2030 -830 {
lab=vss}
N 2070 -900 2300 -900 {
lab=#net13}
N 2030 -830 2180 -830 {
lab=vss}
N 2310 -700 2330 -700 {
lab=#net11}
N 2400 -900 2560 -900 {
lab=clk1}
N 2490 -700 2530 -700 {
lab=clk2}
N 2450 -660 2450 -630 {
lab=vss}
N 2450 -630 2510 -630 {
lab=vss}
N 2360 -860 2360 -830 {
lab=vss}
N 2360 -830 2480 -830 {
lab=vss}
N 480 -330 520 -330 {lab=vss}
N 480 -560 480 -330 {
lab=vss}
N 500 -370 540 -370 {lab=#net4}
N 500 -290 540 -290 {lab=#net7}
N 500 -600 500 -520 {lab=#net4}
N 390 -380 390 -340 {lab=#net14}
N 310 -380 310 -340 {lab=#net15}
N 570 -2850 770 -2850 {
lab=#net16}
N 810 -2900 810 -2880 {
lab=vdd}
N 810 -2800 810 -2760 {
lab=vss}
N 330 -2850 330 -2800 {
lab=#net16}
N 620 -2830 620 -2800 {
lab=snk_cap}
N 620 -2830 770 -2830 {
lab=snk_cap}
N 560 -2780 560 -2760 {
lab=vss}
N 600 -2800 620 -2800 {
lab=snk_cap}
N 1300 -2920 1450 -2920 {
lab=#net17}
N 1335 -2800 1340 -2800 {
lab=vss}
N 1340 -2880 1355 -2880 {
lab=vdd}
N 1260 -2920 1260 -2840 {
lab=#net17}
N 1260 -2840 1300 -2840 {
lab=#net17}
N 1380 -2840 1430 -2840 {
lab=#net18}
N 1380 -2740 1450 -2740 {
lab=#net19}
N 1300 -2780 1340 -2780 {
lab=vdd}
N 460 -2800 520 -2800 {
lab=#net20}
N 330 -2800 380 -2800 {
lab=#net16}
N 420 -2760 460 -2760 {
lab=vss}
N 420 -2840 460 -2840 {
lab=vdd}
N 560 -2760 810 -2760 {
lab=vss}
N 1280 -2700 1340 -2700 {
lab=vss}
N 300 -2850 330 -2850 {
lab=#net16}
N 650 -2900 650 -2890 {
lab=vdd}
N 680 -2900 810 -2900 {
lab=vdd}
N 570 -2860 610 -2860 {
lab=#net16}
N 570 -2860 570 -2850 {
lab=#net16}
N 330 -2850 570 -2850 {
lab=#net16}
N 650 -2860 680 -2860 {
lab=vdd}
N 680 -2900 680 -2860 {
lab=vdd}
N 650 -2900 680 -2900 {
lab=vdd}
N 180 -2840 210 -2840 {lab=#net21}
N 180 -2860 210 -2860 {lab=#net22}
N 860 -2840 910 -2840 {lab=pulseOut}
N 1080 -2980 1080 -2960 {lab=src_n}
N 1050 -2980 1080 -2980 {lab=src_n}
N 1130 -2920 1260 -2920 {lab=#net17}
N 980 -2920 1030 -2920 {lab=pulseOut}
N 1300 -2950 1300 -2920 {lab=#net17}
N 1260 -2920 1300 -2920 {
lab=#net17}
N 1300 -3050 1300 -2980 {lab=vdd}
N 1300 -3050 1340 -3050 {lab=vdd}
N 1080 -2980 1260 -2980 {lab=src_n}
N 1090 -2800 1090 -2780 {lab=snk}
N 1060 -2800 1090 -2800 {lab=snk}
N 990 -2740 1040 -2740 {lab=pulseOut}
N 1210 -2740 1300 -2740 {lab=snk_gate_n}
N 1090 -2800 1170 -2800 {lab=snk}
N 1210 -2860 1210 -2800 {lab=vdd}
N 1210 -2860 1230 -2860 {lab=vdd}
N 1210 -2770 1210 -2740 {lab=snk_gate_n}
N 1140 -2740 1210 -2740 {lab=snk_gate_n}
N 3350 -1080 3450 -1080 {lab=cmp}
N 3450 -1080 3450 -980 {lab=cmp}
N 3450 -1160 3450 -1080 {lab=cmp}
N 3820 -1160 3970 -1160 {
lab=src_gate}
N 3855 -1040 3860 -1040 {
lab=vss}
N 3860 -1120 3875 -1120 {
lab=vdd}
N 3780 -1160 3780 -1080 {
lab=src_gate}
N 3780 -1080 3820 -1080 {
lab=src_gate}
N 3900 -1080 4150 -1080 {
lab=src_gate_n}
N 3600 -1220 3600 -1200 {lab=src_n}
N 3570 -1220 3600 -1220 {lab=src_n}
N 3650 -1160 3780 -1160 {lab=src_gate}
N 3820 -1190 3820 -1160 {lab=src_gate}
N 3780 -1160 3820 -1160 {
lab=src_gate}
N 3820 -1290 3820 -1220 {lab=vdd}
N 3820 -1290 3860 -1290 {lab=vdd}
N 3600 -1220 3780 -1220 {lab=src_n}
N 3610 -1040 3610 -1020 {lab=snk}
N 3580 -1040 3610 -1040 {lab=snk}
N 3770 -980 4030 -980 {lab=snk_gate_n}
N 3450 -1160 3550 -1160 {lab=cmp}
N 3450 -980 3560 -980 {lab=cmp}
N 3770 -980 3770 -890 {lab=snk_gate_n}
N 3660 -980 3770 -980 {lab=snk_gate_n}
N 3770 -860 3770 -830 {lab=vss}
N 3700 -860 3730 -860 {lab=#net23}
N 3970 -1220 3970 -1160 {lab=src_gate}
N 4110 -980 4190 -980 {lab=snk_gate}
N 4150 -1220 4150 -1080 {lab=src_gate_n}
N 4150 -1220 4190 -1220 {lab=src_gate_n}
N 4190 -1040 4190 -980 {lab=snk_gate}
N 6270 -3500 6270 -3440 {
lab=vdd}
N 6270 -2330 6270 -2290 {
lab=vss}
N 6180 -3440 6230 -3440 {
lab=pbias}
N 6200 -2330 6230 -2330 {
lab=nbias}
N 7430 -2320 7510 -2320 {
lab=Vpre}
N 6270 -2870 6270 -2750 {
lab=#net24}
N 6450 -3020 6450 -3000 {
lab=vss}
N 6450 -3000 6510 -3000 {
lab=vss}
N 6490 -3050 6515 -3050 {
lab=src_gate}
N 6380 -2650 6380 -2630 {
lab=vdd}
N 6380 -2650 6430 -2650 {
lab=vdd}
N 6420 -2600 6470 -2600 {
lab=snk_gate_n}
N 6270 -2380 6270 -2350 {
lab=#net25}
N 6270 -3410 6270 -3370 {
lab=#net26}
N 7430 -2070 7430 -1990 {
lab=vss}
N 7470 -2070 7540 -2070 {
lab=preChrg}
N 7430 -2130 7430 -2100 {
lab=#net27}
N 7430 -2220 7430 -2190 {
lab=#net28}
N 7430 -1990 7500 -1990 {
lab=vss}
N 7410 -1990 7430 -1990 {
lab=vss}
N 7430 -2700 7430 -2670 {
lab=#net29}
N 7430 -2830 7430 -2780 {
lab=vdd}
N 7430 -2830 7490 -2830 {
lab=vdd}
N 7430 -2590 7430 -2560 {
lab=#net30}
N 6270 -3270 6450 -3270 {
lab=#net31}
N 6180 -2290 6270 -2290 {
lab=vss}
N 6270 -3050 6450 -3050 {
lab=vdd}
N 6270 -2600 6380 -2600 {
lab=vss}
N 6270 -2470 6270 -2440 {
lab=#net32}
N 6380 -2570 6380 -2470 {
lab=#net32}
N 6270 -2470 6380 -2470 {
lab=#net32}
N 6270 -2570 6270 -2470 {
lab=#net32}
N 6450 -3270 6450 -3080 {
lab=#net31}
N 6610 -3275 6610 -3210 {
lab=#net33}
N 6610 -3150 6610 -2870 {
lab=#net24}
N 6680 -2870 6760 -2870 {
lab=#net24}
N 6820 -2870 6910 -2870 {
lab=vctrl}
N 6610 -3380 6610 -3345 {
lab=#net34}
N 6610 -3500 6610 -3440 {
lab=vdd}
N 6270 -3270 6270 -3220 {
lab=#net31}
N 6270 -3160 6270 -3080 {
lab=#net35}
N 6720 -2660 6810 -2660 {
lab=preChrg}
N 6665 -2660 6680 -2660 {
lab=vss}
N 6680 -2870 6680 -2750 {
lab=#net24}
N 7430 -2320 7430 -2300 {lab=Vpre}
N 7410 -2260 7410 -1990 {
lab=vss}
N 7430 -2300 7460 -2300 {lab=Vpre}
N 7430 -2220 7460 -2220 {lab=#net28}
N 7410 -2260 7440 -2260 {lab=vss}
N 7430 -2370 7430 -2320 {lab=Vpre}
N 7430 -2480 7430 -2450 {lab=#net36}
N 7410 -2740 7410 -2260 {
lab=vss}
N 6680 -2470 6680 -2410 {lab=vss}
N 6680 -2410 6710 -2410 {lab=vss}
N 7990 -2030 8080 -2030 {
lab=nbias}
N 7990 -2030 7990 -2010 {
lab=nbias}
N 8200 -2360 8200 -2330 {
lab=pbias}
N 8110 -2330 8200 -2330 {
lab=pbias}
N 8110 -2390 8110 -2330 {
lab=pbias}
N 8110 -2390 8160 -2390 {
lab=pbias}
N 8200 -2450 8200 -2390 {
lab=vdd}
N 7990 -1980 7990 -1930 {
lab=vss}
N 7930 -1930 7990 -1930 {
lab=vss}
N 8080 -2030 8080 -1980 {
lab=nbias}
N 8030 -1980 8080 -1980 {
lab=nbias}
N 8200 -1980 8200 -1930 {
lab=vss}
N 8080 -1980 8160 -1980 {
lab=nbias}
N 8200 -2330 8200 -2300 {
lab=pbias}
N 7930 -2530 7970 -2530 {
lab=vss}
N 7990 -2770 7990 -2730 {
lab=vdd}
N 7930 -2610 7930 -2530 {
lab=vss}
N 7930 -2530 7930 -1930 {
lab=vss}
N 7990 -1930 8200 -1930 {
lab=vss}
N 7930 -2610 7970 -2610 {
lab=vss}
N 7930 -2690 7930 -2610 {
lab=vss}
N 7990 -2050 7990 -2030 {lab=nbias}
N 8200 -2240 8200 -2010 {lab=#net37}
N 7990 -2490 7990 -2290 {lab=ncasc}
N 7990 -2290 8080 -2290 {lab=ncasc}
N 8080 -2290 8080 -2230 {lab=ncasc}
N 7990 -2290 7990 -2260 {lab=ncasc}
N 8030 -2230 8080 -2230 {lab=ncasc}
N 7990 -2200 7990 -2110 {lab=#net38}
N 7930 -2690 7970 -2690 {lab=vss}
N 5390 -2840 5490 -2840 {lab=cmp}
N 5490 -2840 5490 -2600 {lab=cmp}
N 5490 -3050 5490 -2840 {lab=cmp}
N 5640 -3110 5640 -3090 {lab=src_n}
N 5610 -3110 5640 -3110 {lab=src_n}
N 5930 -3050 6000 -3050 {lab=src_gate}
N 5650 -2660 5650 -2640 {lab=snk}
N 5490 -3050 5590 -3050 {lab=cmp}
N 5490 -2600 5600 -2600 {lab=cmp}
N 5930 -2950 5930 -2920 {lab=vss}
N 5860 -2950 5890 -2950 {lab=#net39}
N 6010 -2600 6230 -2600 {lab=snk_gate}
N 5760 -2730 5760 -2660 {lab=vdd}
N 5760 -2730 5800 -2730 {lab=vdd}
N 5650 -2660 5720 -2660 {lab=snk}
N 5760 -2630 5760 -2600 {lab=snk_gate_n}
N 5700 -2600 5760 -2600 {lab=snk_gate_n}
N 5760 -2600 5930 -2600 {lab=snk_gate_n}
N 6080 -3050 6230 -3050 {lab=src_gate_n}
N 5930 -3050 5930 -2980 {lab=src_gate}
N 5690 -3050 5930 -3050 {lab=src_gate}
N 6270 -2870 6610 -2870 {lab=#net24}
N 6270 -3020 6270 -2870 {
lab=#net24}
N 6610 -2870 6680 -2870 {lab=#net24}
N 6270 -2690 6270 -2630 {lab=#net40}
N 6270 -3500 6610 -3500 {lab=vdd}
N 6180 -3500 6270 -3500 {lab=vdd}
N 6270 -3310 6270 -3270 {lab=#net31}
N 6680 -2630 6680 -2580 {lab=Vpre}
N 6190 -2010 6190 -1950 {
lab=vdd}
N 6190 -840 6190 -800 {
lab=vss}
N 6100 -1950 6150 -1950 {
lab=pbias}
N 6120 -840 6150 -840 {
lab=nbias}
N 6190 -1380 6190 -1260 {
lab=#net41}
N 6370 -1530 6370 -1510 {
lab=vss}
N 6370 -1510 6430 -1510 {
lab=vss}
N 6410 -1560 6435 -1560 {
lab=src_gate}
N 6300 -1160 6300 -1140 {
lab=vdd}
N 6300 -1160 6350 -1160 {
lab=vdd}
N 6340 -1110 6390 -1110 {
lab=snk_gate_n}
N 6190 -890 6190 -860 {
lab=#net42}
N 6190 -1920 6190 -1880 {
lab=#net43}
N 6190 -1780 6370 -1780 {
lab=#net44}
N 6100 -800 6190 -800 {
lab=vss}
N 6190 -980 6190 -950 {
lab=#net45}
N 6300 -1080 6300 -980 {
lab=#net45}
N 6190 -980 6300 -980 {
lab=#net45}
N 6190 -1080 6190 -980 {
lab=#net45}
N 6370 -1780 6370 -1590 {
lab=#net44}
N 6530 -1785 6530 -1720 {
lab=#net46}
N 6530 -1660 6530 -1380 {
lab=#net41}
N 6600 -1380 6680 -1380 {
lab=#net41}
N 6740 -1380 6830 -1380 {
lab=vctrl}
N 6530 -1890 6530 -1855 {
lab=#net47}
N 6530 -2010 6530 -1950 {
lab=vdd}
N 6190 -1780 6190 -1730 {
lab=#net44}
N 6190 -1670 6190 -1590 {
lab=#net48}
N 6640 -1170 6730 -1170 {
lab=preChrg}
N 6585 -1170 6600 -1170 {
lab=vss}
N 6600 -1380 6600 -1260 {
lab=#net41}
N 6600 -980 6600 -920 {lab=vss}
N 6600 -920 6630 -920 {lab=vss}
N 5310 -1350 5410 -1350 {lab=cmp}
N 5570 -1570 5610 -1570 {lab=src_n}
N 6190 -1380 6530 -1380 {lab=#net41}
N 6190 -1530 6190 -1380 {
lab=#net41}
N 6530 -1380 6600 -1380 {lab=#net41}
N 6190 -1200 6190 -1140 {lab=#net49}
N 6190 -2010 6530 -2010 {lab=vdd}
N 6100 -2010 6190 -2010 {lab=vdd}
N 6190 -1820 6190 -1780 {lab=#net44}
N 6600 -1140 6600 -1090 {lab=Vpre}
N 5860 -1560 5860 -1490 {lab=vdd}
N 5700 -1560 5860 -1560 {lab=vdd}
N 5860 -1490 5900 -1490 {lab=vdd}
N 5980 -1490 6030 -1490 {lab=src_gate}
N 5860 -1110 6300 -1110 {lab=vss}
N 5860 -1560 6370 -1560 {lab=vdd}
N 5410 -1550 5410 -1350 {lab=cmp}
N 5410 -1550 5610 -1550 {lab=cmp}
N 5410 -1040 5600 -1040 {lab=cmp}
N 5410 -1350 5410 -1040 {lab=cmp}
N 5600 -1100 5600 -1040 {lab=cmp}
N 5600 -1100 5630 -1100 {lab=cmp}
N 5560 -1120 5630 -1120 {lab=#net50}
N 5440 -1120 5480 -1120 {lab=snk}
N 5860 -1020 5880 -1020 {lab=vss}
N 5860 -1110 5860 -1020 {lab=vss}
N 5720 -1110 5860 -1110 {lab=vss}
N 5960 -1020 6040 -1020 {lab=snk_gate_n}
C {devices/ipin.sym} 120 -1010 0 0 {name=p4 lab=vss}
C {devices/ipin.sym} 120 -1040 0 0 {name=p5 lab=vdd}
C {devices/lab_wire.sym} 1140 -180 0 0 {name=p32 sig_type=std_logic lab=pbias}
C {devices/lab_wire.sym} 960 -500 0 0 {name=p34 sig_type=std_logic lab=vdd}
C {JNW_ATR_SKY130A/JNWATR_PCH_8C5F0.sym} 1140 -240 0 0 {name=x7 }
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 920 -70 0 0 {name=x28 }
C {devices/lab_wire.sym} 930 -120 0 0 {name=p12 sig_type=std_logic lab=nbias}
C {devices/lab_wire.sym} 1180 -300 0 0 {name=p13 sig_type=std_logic lab=vdd}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 1140 -70 0 0 {name=x4 }
C {devices/lab_wire.sym} 1130 -70 0 0 {name=p14 sig_type=std_logic lab=nbias}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 960 -230 3 0 {name=x26 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 960 -310 3 0 {name=x27 }
C {JNW_TR_SKY130A/JNWTR_RPPO8.sym} 960 -390 3 0 {name=x11 }
C {sky130_fd_pr/pnp_05v5.sym} 520 -180 0 1 {name=Q1
model=pnp_05v5_W3p40L3p40
m=8
spiceprefix=X
}
C {sky130_fd_pr/pnp_05v5.sym} 220 -260 0 1 {name=Q2
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {devices/lab_wire.sym} 340 -1330 0 1 {name=p29 sig_type=std_logic lab=vdd

}
C {devices/opin.sym} 130 -790 2 0 {name=p44 lab=vn}
C {JNW_ATR_SKY130A/JNWATR_PCH_4C1F2.sym} 460 -1230 0 0 {name=x2 }
C {JNW_ATR_SKY130A/JNWATR_PCH_4C1F2.sym} 240 -1230 0 1 {name=x3 }
C {JNW_ATR_SKY130A/JNWATR_PCH_4C1F2.sym} 700 -1230 0 0 {name=x5 }
C {devices/lab_wire.sym} 340 -1230 0 1 {name=p8 sig_type=std_logic lab=vctrl

}
C {devices/lab_wire.sym} 620 -1230 0 1 {name=p9 sig_type=std_logic lab=vctrl

}
C {devices/lab_wire.sym} 620 -20 0 0 {name=p3 sig_type=std_logic lab=vss
}
C {devices/opin.sym} 570 -790 0 0 {name=p7 lab=vp}
C {devices/opin.sym} 780 -930 0 0 {name=p10 lab=vref}
C {devices/lab_wire.sym} 700 -700 0 0 {name=p11 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 740 -740 1 0 {name=x6 }
C {devices/vsource.sym} 500 -1100 0 0 {name=v_itot1 value=0 savecurrent=true}
C {devices/vsource.sym} 500 -720 0 0 {name=v_ip1 value=0 savecurrent=true}
C {devices/vsource.sym} 390 -720 0 0 {name=v_ip2 value=0 savecurrent=true}
C {devices/vsource.sym} 200 -720 0 0 {name=v_in1 value=0 savecurrent=true}
C {devices/vsource.sym} 310 -720 0 0 {name=v_in2 value=0 savecurrent=true}
C {devices/isource.sym} 1060 -970 0 0 {name=IVBE value=7u}
C {devices/lab_wire.sym} 1100 -1030 0 0 {name=p15 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 1110 -700 0 0 {name=p16 sig_type=std_logic lab=vss
}
C {devices/opin.sym} 1090 -890 0 0 {name=p17 lab=VBE}
C {sky130_fd_pr/pnp_05v5.sym} 1080 -790 0 1 {name=Q3
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {devices/ipin.sym} 1310 -1080 0 0 {name=p18 lab=B}
C {JNW_AVV_SKY130A/xor.sym} 1410 -1090 0 0 {name=x16}
C {devices/lab_wire.sym} 1410 -1150 0 0 {name=p20 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 1410 -1030 0 0 {name=p21 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 500 -370 1 0 {name=x18 }
C {JNW_AVV_SKY130A/OTA.sym} 350 -1000 3 0 {name=x1}
C {devices/lab_wire.sym} 260 -1050 0 1 {name=p1 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 440 -1050 0 0 {name=p2 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 890 -1520 0 0 {name=p6 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 910 -1530 0 0 {name=p24 sig_type=std_logic lab=B
}
C {devices/lab_wire.sym} 970 -1450 0 0 {name=p25 sig_type=std_logic lab=y
}
C {devices/switch_v_xyce.sym} 910 -1450 1 0 {.MODEL SWITCH1 SW(VT=0.5 VH=0.01 RON=0.01 ROFF=10000000)

name=S1 model=SWITCH1 state=OFF

}
C {devices/netlist.sym} 900 -1300 0 0 {name=s2 value=".MODEL SWITCH1 SW(VT=0.9 RON=1 ROFF=1000000000)"
}
C {devices/res.sym} 980 -1420 0 0 {name=R1
value=1k
footprint=1206
device=resistor
m=1}
C {devices/lab_wire.sym} 1040 -1390 0 0 {name=p22 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_NDX1_CV.sym} 1850 -690 0 0 {name=x13 }
C {devices/lab_wire.sym} 1890 -740 0 0 {name=p26 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 1890 -660 0 0 {name=p27 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_NDX1_CV.sym} 1840 -890 0 0 {name=x15 }
C {devices/lab_wire.sym} 1880 -940 0 0 {name=p28 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 1880 -860 0 0 {name=p30 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 1690 -840 1 0 {name=x17 }
C {devices/lab_wire.sym} 1650 -800 0 0 {name=p31 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 1730 -800 0 0 {name=p33 sig_type=std_logic lab=vdd}
C {devices/ipin.sym} 1600 -910 0 0 {name=p35 lab=A}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 1970 -1070 0 0 {name=x23 }
C {devices/lab_wire.sym} 2010 -1030 3 0 {name=p36 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 2010 -1110 3 0 {name=p37 sig_type=std_logic lab=vdd}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 2050 -1070 0 0 {name=x24 }
C {devices/lab_wire.sym} 2090 -1030 3 0 {name=p38 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 2090 -1110 3 0 {name=p39 sig_type=std_logic lab=vdd}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 2130 -1070 0 0 {name=x25 }
C {devices/lab_wire.sym} 2170 -1030 3 0 {name=p40 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 2170 -1110 3 0 {name=p41 sig_type=std_logic lab=vdd}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 2210 -1070 0 0 {name=x29 }
C {devices/lab_wire.sym} 2250 -1030 3 0 {name=p42 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 2250 -1110 3 0 {name=p43 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 2560 -900 0 0 {name=p53 sig_type=std_logic lab=clk1}
C {devices/lab_wire.sym} 2530 -700 0 0 {name=p54 sig_type=std_logic lab=clk2}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 2320 -900 0 0 {name=x34 }
C {devices/lab_wire.sym} 2360 -860 3 0 {name=p19 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 2360 -940 3 0 {name=p23 sig_type=std_logic lab=vdd}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 2210 -640 0 0 {name=x1[3:0]}
C {devices/lab_wire.sym} 2110 -630 3 0 {name=p45 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 2180 -840 0 0 {name=x2[3:0]}
C {devices/lab_wire.sym} 2080 -830 3 0 {name=p46 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 2330 -700 0 0 {name=x32 }
C {devices/lab_wire.sym} 2370 -660 3 0 {name=p47 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 2370 -740 3 0 {name=p48 sig_type=std_logic lab=vdd}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 2410 -700 0 0 {name=x35 }
C {devices/lab_wire.sym} 2450 -660 3 0 {name=p51 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 2450 -740 3 0 {name=p52 sig_type=std_logic lab=vdd}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 2480 -840 0 0 {name=x3[2:0]}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 2510 -640 0 0 {name=x4[2:0]}
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 2020 -700 0 0 {name=x31 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 1990 -900 0 0 {name=x30 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 540 -370 1 0 {name=x33 }
C {JNW_TR_SKY130A/JNWTR_RPPO8.sym} 390 -340 1 0 {name=x8 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 390 -460 1 0 {name=x9 }
C {JNW_TR_SKY130A/JNWTR_RPPO8.sym} 310 -340 3 1 {name=x10 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 310 -460 3 1 {name=x12 }
C {devices/lab_wire.sym} 775 -2900 0 1 {name=p130 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 775 -2760 0 1 {name=p131 sig_type=std_logic lab=vss}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 710 -2770 0 0 {name=x9[7:0]}
C {devices/lab_wire.sym} 755 -2830 0 0 {name=p134 sig_type=std_logic lab=snk_cap}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 1300 -2840 0 0 {name=x74 }
C {devices/lab_wire.sym} 1355 -2880 0 1 {name=p135 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 1335 -2800 0 0 {name=p136 sig_type=std_logic lab=vss}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 1300 -2740 0 0 {name=x75 }
C {devices/lab_wire.sym} 1235 -2740 0 1 {name=p137 sig_type=std_logic lab=snk_gate_n}
C {JNW_TR_SKY130A/JNWTR_NDX1_CV.sym} 770 -2830 0 0 {name=x76 }
C {devices/lab_wire.sym} 1325 -2700 0 0 {name=p138 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 1305 -2780 0 1 {name=p139 sig_type=std_logic lab=vdd}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 380 -2800 0 0 {name=x77 }
C {devices/lab_wire.sym} 435 -2760 0 1 {name=p140 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 445 -2840 0 1 {name=p141 sig_type=std_logic lab=vdd}
C {JNW_ATR_SKY130A/JNWATR_PCH_2C1F2.sym} 610 -2860 0 0 {name=x78 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 520 -2800 0 0 {name=x79 }
C {JNW_TR_SKY130A/JNWTR_ORX1_CV.sym} 210 -2840 0 0 {name=x80 }
C {devices/lab_wire.sym} 250 -2890 0 1 {name=p142 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 250 -2810 0 1 {name=p143 sig_type=std_logic lab=vss

}
C {devices/lab_wire.sym} 880 -2840 0 1 {name=p144 sig_type=std_logic lab=pulseOut

}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1020 -2920 0 0 {name=x81 }
C {devices/lab_wire.sym} 1110 -2960 0 1 {name=p145 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 1110 -2870 0 1 {name=p146 sig_type=std_logic lab=vss

}
C {devices/lab_wire.sym} 1080 -2980 0 0 {name=p147 sig_type=std_logic lab=src_n

}
C {devices/lab_wire.sym} 1020 -2920 0 0 {name=p148 sig_type=std_logic lab=pulseOut

}
C {devices/lab_wire.sym} 1310 -3050 0 1 {name=p149 sig_type=std_logic lab=vdd

}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1030 -2740 0 0 {name=x82 }
C {devices/lab_wire.sym} 1120 -2780 0 1 {name=p150 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 1120 -2690 0 1 {name=p151 sig_type=std_logic lab=vss

}
C {devices/lab_wire.sym} 1090 -2800 0 0 {name=p152 sig_type=std_logic lab=snk

}
C {devices/lab_wire.sym} 1030 -2740 0 0 {name=p153 sig_type=std_logic lab=pulseOut

}
C {JNW_ATR_SKY130A/JNWATR_PCH_2C1F2.sym} 1260 -2980 0 0 {name=x83 }
C {JNW_ATR_SKY130A/JNWATR_PCH_2C1F2.sym} 1170 -2800 0 0 {name=x84 }
C {devices/lab_wire.sym} 1210 -2860 0 1 {name=p154 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 4175 -1220 0 0 {name=p55 sig_type=std_logic lab=src_gate_n}
C {devices/lab_wire.sym} 4165 -980 0 0 {name=p56 sig_type=std_logic lab=snk_gate}
C {devices/ipin.sym} 3350 -1080 0 0 {name=p57 lab=cmp}
C {devices/lab_wire.sym} 3955 -1160 0 1 {name=p58 sig_type=std_logic lab=src_gate}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 3820 -1080 0 0 {name=x19 }
C {devices/lab_wire.sym} 3875 -1120 0 1 {name=p59 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 3855 -1040 0 0 {name=p60 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 3855 -980 0 1 {name=p61 sig_type=std_logic lab=snk_gate_n}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 3540 -1160 0 0 {name=x20 }
C {devices/lab_wire.sym} 3630 -1200 0 1 {name=p62 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 3630 -1110 0 1 {name=p63 sig_type=std_logic lab=vss

}
C {devices/lab_wire.sym} 3600 -1220 0 0 {name=p64 sig_type=std_logic lab=src_n

}
C {devices/lab_wire.sym} 3830 -1290 0 1 {name=p65 sig_type=std_logic lab=vdd

}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 3550 -980 0 0 {name=x21 }
C {devices/lab_wire.sym} 3640 -1020 0 1 {name=p66 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 3640 -930 0 1 {name=p67 sig_type=std_logic lab=vss

}
C {devices/lab_wire.sym} 3610 -1040 0 0 {name=p68 sig_type=std_logic lab=snk

}
C {JNW_ATR_SKY130A/JNWATR_PCH_2C1F2.sym} 3780 -1220 0 0 {name=x22 }
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 4030 -980 0 0 {name=x36 }
C {devices/lab_wire.sym} 4070 -940 0 1 {name=p69 sig_type=std_logic lab=vss

}
C {devices/lab_wire.sym} 4070 -1020 0 1 {name=p70 sig_type=std_logic lab=vdd

}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C1F2.sym} 3730 -860 0 0 {name=x37 }
C {devices/lab_wire.sym} 3770 -830 0 1 {name=p71 sig_type=std_logic lab=vss

}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 3620 -860 0 0 {name=x38 }
C {devices/lab_wire.sym} 3660 -820 0 1 {name=p72 sig_type=std_logic lab=vss

}
C {devices/lab_wire.sym} 3660 -900 0 1 {name=p73 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 3620 -860 0 0 {name=p173 sig_type=std_logic lab=snk

}
C {devices/ipin.sym} 6180 -3500 0 0 {name=p113 lab=vdd}
C {devices/opin.sym} 6910 -2870 0 0 {name=p114 lab=vctrl}
C {devices/ipin.sym} 6180 -2290 0 0 {name=p115 lab=vss
}
C {JNW_TR_SKY130A/JNWTR_CAPX4.sym} 6610 -3285 0 0 {name=x8[30:0]}
C {devices/ipin.sym} 6810 -2660 2 0 {name=p116 lab=preChrg
}
C {devices/lab_wire.sym} 7445 -2830 0 1 {name=p117 sig_type=std_logic lab=vdd}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 6230 -2330 0 0 {name=x60 }
C {devices/lab_wire.sym} 6295 -3050 0 1 {name=p118 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 7465 -1990 0 1 {name=p119 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 7475 -2320 0 1 {name=p120 sig_type=std_logic lab=Vpre}
C {JNW_ATR_SKY130A/JNWATR_PCH_2C1F2.sym} 6230 -3050 0 0 {name=x61 }
C {JNW_ATR_SKY130A/JNWATR_NCH_2C1F2.sym} 6230 -2600 0 0 {name=x62 }
C {JNW_ATR_SKY130A/JNWATR_PCH_2C1F2.sym} 6490 -3050 0 1 {name=x63 }
C {devices/lab_wire.sym} 6505 -3000 0 0 {name=p121 sig_type=std_logic lab=vss}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C1F2.sym} 6420 -2600 0 1 {name=x64 }
C {devices/lab_wire.sym} 6335 -2600 0 0 {name=p123 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 6445 -2600 0 1 {name=p124 sig_type=std_logic lab=snk_gate_n}
C {devices/vsource.sym} 6270 -3340 0 0 {name=V_isrc1 value=0 savecurrent=true}
C {devices/vsource.sym} 6270 -2410 0 0 {name=V_isnk1 value=0 savecurrent=true}
C {JNW_ATR_SKY130A/JNWATR_PCH_2C5F0.sym} 6230 -3440 0 0 {name=x65 }
C {devices/vsource.sym} 7430 -2160 0 0 {name=V_iPreCharge2 value=0 savecurrent=true}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C1F2.sym} 7470 -2070 0 1 {name=x66 }
C {devices/lab_wire.sym} 7485 -2070 0 1 {name=p125 sig_type=std_logic lab=preChrg}
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 7430 -2300 1 0 {name=x67 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 7430 -2670 1 0 {name=x68 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 7430 -2780 1 0 {name=x69 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 7430 -2560 1 0 {name=x70 }
C {devices/vsource.sym} 6270 -2720 0 0 {name=V_isnk_drain1 value=0 savecurrent=true}
C {devices/vsource.sym} 6270 -3190 0 0 {name=V_isrc_source1 value=0 savecurrent=true}
C {devices/lab_wire.sym} 6415 -2650 0 1 {name=p126 sig_type=std_logic lab=vdd}
C {devices/vsource.sym} 6610 -3180 0 0 {name=V_icap_bot1 value=0 savecurrent=true}
C {devices/vsource.sym} 6680 -2720 0 0 {name=V_iprecharge3 value=0 savecurrent=true}
C {devices/vsource.sym} 6790 -2870 1 0 {name=V_ipmosGate1 value=0 savecurrent=true}
C {devices/vsource.sym} 6610 -3410 0 0 {name=V_icap_top1 value=0 savecurrent=true}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C1F2.sym} 6720 -2660 0 1 {name=x71 }
C {devices/lab_wire.sym} 6665 -2660 0 0 {name=p127 sig_type=std_logic lab=vss}
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 7430 -2450 1 0 {name=x72 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 7460 -2300 1 0 {name=x73 }
C {devices/ipin.sym} 5690 -3360 0 0 {name=p128 lab=snk
}
C {devices/ipin.sym} 5690 -3380 0 0 {name=p129 lab=src_n}
C {devices/vsource.sym} 6680 -2500 0 0 {name=V_iPreCharge6 value=240m savecurrent=true}
C {devices/lab_wire.sym} 6685 -2410 0 1 {name=p155 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 8160 -2330 0 0 {name=p174 sig_type=std_logic lab=pbias}
C {devices/lab_wire.sym} 7990 -2770 0 1 {name=p175 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 8080 -1930 0 1 {name=p176 sig_type=std_logic lab=vss}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 8030 -1980 0 1 {name=x28[3:0]}
C {devices/lab_wire.sym} 8200 -2450 0 0 {name=p177 sig_type=std_logic lab=vdd}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 8160 -1980 0 0 {name=x92 }
C {devices/lab_wire.sym} 8140 -1980 0 0 {name=p178 sig_type=std_logic lab=nbias}
C {devices/vsource.sym} 7990 -2080 0 0 {name=v_nbias value=0 savecurrent=true}
C {devices/vsource.sym} 8200 -2270 0 0 {name=v_pbias value=0 savecurrent=true}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 7990 -2570 1 1 {name=x93 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 7990 -2650 1 1 {name=x94 }
C {JNW_ATR_SKY130A/JNWATR_PCH_2C5F0.sym} 8160 -2390 0 0 {name=x95 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 7990 -2490 1 1 {name=x96 }
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 8030 -2230 0 1 {name=x97 }
C {devices/lab_wire.sym} 7990 -2230 0 0 {name=p179 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 6210 -3440 0 0 {name=p180 sig_type=std_logic lab=pbias}
C {devices/lab_wire.sym} 6220 -2330 0 0 {name=p181 sig_type=std_logic lab=nbias}
C {devices/lab_wire.sym} 8050 -2290 0 0 {name=p182 sig_type=std_logic lab=ncasc}
C {devices/lab_wire.sym} 6680 -2580 0 1 {name=p49 sig_type=std_logic lab=Vpre

}
C {devices/lab_wire.sym} 6215 -3050 0 0 {name=p50 sig_type=std_logic lab=src_gate_n}
C {devices/lab_wire.sym} 6205 -2600 0 0 {name=p74 sig_type=std_logic lab=snk_gate}
C {devices/ipin.sym} 5390 -2840 0 0 {name=p75 lab=cmp}
C {devices/lab_wire.sym} 5875 -3050 0 1 {name=p76 sig_type=std_logic lab=src_gate}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 6000 -3050 0 0 {name=x14 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 5580 -3050 0 0 {name=x39 }
C {devices/lab_wire.sym} 5670 -3090 0 1 {name=p77 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 5670 -3000 0 1 {name=p78 sig_type=std_logic lab=vss

}
C {devices/lab_wire.sym} 5640 -3110 0 0 {name=p79 sig_type=std_logic lab=src_n

}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 5590 -2600 0 0 {name=x40 }
C {devices/lab_wire.sym} 5680 -2640 0 1 {name=p80 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 5680 -2550 0 1 {name=p81 sig_type=std_logic lab=vss

}
C {devices/lab_wire.sym} 5650 -2660 0 0 {name=p82 sig_type=std_logic lab=snk

}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 5930 -2600 0 0 {name=x41 }
C {devices/lab_wire.sym} 5970 -2560 0 1 {name=p83 sig_type=std_logic lab=vss

}
C {devices/lab_wire.sym} 5970 -2640 0 1 {name=p84 sig_type=std_logic lab=vdd

}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C1F2.sym} 5890 -2950 0 0 {name=x42 }
C {devices/lab_wire.sym} 5930 -2920 0 1 {name=p85 sig_type=std_logic lab=vss

}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 5780 -2950 0 0 {name=x43 }
C {devices/lab_wire.sym} 5820 -2910 0 1 {name=p86 sig_type=std_logic lab=vss

}
C {devices/lab_wire.sym} 5820 -2990 0 1 {name=p87 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 5780 -2950 0 0 {name=p88 sig_type=std_logic lab=src_n

}
C {devices/lab_wire.sym} 5770 -2730 0 1 {name=p89 sig_type=std_logic lab=vdd

}
C {JNW_ATR_SKY130A/JNWATR_PCH_2C1F2.sym} 5720 -2660 0 0 {name=x44 }
C {devices/lab_wire.sym} 6505 -3050 0 1 {name=p90 sig_type=std_logic lab=src_gate}
C {devices/lab_wire.sym} 5815 -2600 0 1 {name=p91 sig_type=std_logic lab=snk_gate_n}
C {devices/lab_wire.sym} 6040 -3090 0 1 {name=p92 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 6040 -3010 0 1 {name=p93 sig_type=std_logic lab=vss

}
C {devices/ipin.sym} 6100 -2010 0 0 {name=p94 lab=vdd}
C {devices/opin.sym} 6830 -1380 0 0 {name=p95 lab=vctrl}
C {devices/ipin.sym} 6100 -800 0 0 {name=p96 lab=vss
}
C {JNW_TR_SKY130A/JNWTR_CAPX4.sym} 6530 -1795 0 0 {name=x5[30:0]}
C {devices/ipin.sym} 6730 -1170 2 0 {name=p97 lab=preChrg
}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 6150 -840 0 0 {name=x45 }
C {devices/lab_wire.sym} 6215 -1560 0 1 {name=p98 sig_type=std_logic lab=vdd}
C {JNW_ATR_SKY130A/JNWATR_PCH_2C1F2.sym} 6150 -1560 0 0 {name=x46 }
C {JNW_ATR_SKY130A/JNWATR_NCH_2C1F2.sym} 6150 -1110 0 0 {name=x47 }
C {JNW_ATR_SKY130A/JNWATR_PCH_2C1F2.sym} 6410 -1560 0 1 {name=x48 }
C {devices/lab_wire.sym} 6425 -1510 0 0 {name=p99 sig_type=std_logic lab=vss}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C1F2.sym} 6340 -1110 0 1 {name=x49 }
C {devices/lab_wire.sym} 6255 -1110 0 0 {name=p100 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 6365 -1110 0 1 {name=p101 sig_type=std_logic lab=snk_gate_n}
C {devices/vsource.sym} 6190 -1850 0 0 {name=V_isrc2 value=0 savecurrent=true}
C {devices/vsource.sym} 6190 -920 0 0 {name=V_isnk2 value=0 savecurrent=true}
C {JNW_ATR_SKY130A/JNWATR_PCH_2C5F0.sym} 6150 -1950 0 0 {name=x50 }
C {devices/vsource.sym} 6190 -1230 0 0 {name=V_isnk_drain2 value=0 savecurrent=true}
C {devices/vsource.sym} 6190 -1700 0 0 {name=V_isrc_source2 value=0 savecurrent=true}
C {devices/lab_wire.sym} 6335 -1160 0 1 {name=p102 sig_type=std_logic lab=vdd}
C {devices/vsource.sym} 6530 -1690 0 0 {name=V_icap_bot2 value=0 savecurrent=true}
C {devices/vsource.sym} 6600 -1230 0 0 {name=V_iprecharge1 value=0 savecurrent=true}
C {devices/vsource.sym} 6710 -1380 1 0 {name=V_ipmosGate2 value=0 savecurrent=true}
C {devices/vsource.sym} 6530 -1920 0 0 {name=V_icap_top2 value=0 savecurrent=true}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C1F2.sym} 6640 -1170 0 1 {name=x51 }
C {devices/lab_wire.sym} 6585 -1170 0 0 {name=p103 sig_type=std_logic lab=vss}
C {devices/vsource.sym} 6600 -1010 0 0 {name=V_iPreCharge4 value=240m savecurrent=true}
C {devices/lab_wire.sym} 6605 -920 0 1 {name=p106 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 6130 -1950 0 0 {name=p107 sig_type=std_logic lab=pbias}
C {devices/lab_wire.sym} 6140 -840 0 0 {name=p108 sig_type=std_logic lab=nbias}
C {devices/lab_wire.sym} 6600 -1090 0 1 {name=p109 sig_type=std_logic lab=Vpre

}
C {devices/lab_wire.sym} 5825 -1560 0 0 {name=p110 sig_type=std_logic lab=src_gate_n}
C {devices/lab_wire.sym} 6125 -1110 0 0 {name=p111 sig_type=std_logic lab=snk_gate}
C {devices/ipin.sym} 5310 -1350 0 0 {name=p112 lab=cmp}
C {devices/lab_wire.sym} 6005 -1490 0 1 {name=p122 sig_type=std_logic lab=src_gate}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 5900 -1490 0 0 {name=x52 }
C {devices/lab_wire.sym} 5600 -1570 0 0 {name=p156 sig_type=std_logic lab=src_n

}
C {devices/lab_wire.sym} 6425 -1560 0 1 {name=p167 sig_type=std_logic lab=src_gate}
C {devices/lab_wire.sym} 5975 -1020 0 1 {name=p168 sig_type=std_logic lab=snk_gate_n}
C {devices/lab_wire.sym} 5940 -1530 0 1 {name=p169 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 5940 -1450 0 1 {name=p170 sig_type=std_logic lab=vss

}
C {devices/lab_wire.sym} 5650 -1600 0 1 {name=p104 sig_type=std_logic lab=vdd

}
C {JNW_TR_SKY130A/JNWTR_NDX1_CV.sym} 5610 -1550 0 0 {name=x53 }
C {devices/lab_wire.sym} 5650 -1520 0 1 {name=p105 sig_type=std_logic lab=vss

}
C {devices/lab_wire.sym} 5670 -1150 0 1 {name=p132 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 5670 -1070 0 1 {name=p133 sig_type=std_logic lab=vss

}
C {devices/lab_wire.sym} 5460 -1120 0 0 {name=p157 sig_type=std_logic lab=snk

}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 5880 -1020 0 0 {name=x55 }
C {devices/lab_wire.sym} 5920 -1060 0 1 {name=p158 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 5920 -980 0 1 {name=p159 sig_type=std_logic lab=vss

}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 5480 -1120 0 0 {name=x56 }
C {devices/lab_wire.sym} 5520 -1160 0 1 {name=p160 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 5520 -1080 0 1 {name=p161 sig_type=std_logic lab=vss

}
C {JNW_TR_SKY130A/JNWTR_NDX1_CV.sym} 5630 -1100 0 0 {name=x54 }
