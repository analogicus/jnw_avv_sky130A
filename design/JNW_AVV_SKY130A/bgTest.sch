v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 870 -120 960 -120 {
lab=nbias}
N 960 -120 960 -100 {
lab=nbias}
N 1180 -210 1180 -180 {
lab=pbias}
N 1090 -180 1180 -180 {
lab=pbias}
N 1090 -240 1090 -180 {
lab=pbias}
N 1090 -240 1140 -240 {
lab=pbias}
N 1180 -300 1180 -240 {
lab=vdd}
N 960 -70 960 -20 {
lab=vss}
N 930 -500 960 -500 {
lab=vdd}
N 1020 -270 1020 -20 {
lab=vss}
N 980 -270 1020 -270 {
lab=vss}
N 1020 -350 1020 -270 {
lab=vss}
N 980 -350 1020 -350 {
lab=vss}
N 1020 -430 1020 -350 {
lab=vss}
N 980 -430 1020 -430 {
lab=vss}
N 960 -500 960 -470 {
lab=vdd}
N 1090 -70 1140 -70 {
lab=nbias}
N 1020 -20 1180 -20 {
lab=vss}
N 1150 -300 1180 -300 {
lab=vdd}
N 870 -120 870 -70 {
lab=nbias}
N 870 -70 920 -70 {
lab=nbias}
N 1180 -70 1180 -20 {
lab=vss}
N 1180 -180 1180 -100 {
lab=pbias}
N 960 -230 960 -120 {
lab=nbias}
N 490 -790 490 -780 {
lab=#net1}
N 500 -800 510 -800 {
lab=#net1}
N 210 -790 210 -780 {
lab=#net2}
N 200 -800 210 -800 {
lab=#net2}
N 510 -790 510 -780 {
lab=#net1}
N 210 -800 210 -790 {
lab=#net2}
N 490 -800 490 -790 {
lab=#net1}
N 390 -790 490 -790 {
lab=#net1}
N 200 -780 210 -780 {
lab=#net2}
N 210 -790 310 -790 {
lab=#net2}
N 190 -790 190 -780 {
lab=#net2}
N 240 -260 240 -210 {
lab=vss}
N 200 -210 240 -210 {
lab=vss}
N 200 -230 200 -210 {
lab=vss}
N 540 -180 540 -130 {
lab=vss}
N 500 -130 540 -130 {
lab=vss}
N 500 -150 500 -130 {
lab=vss}
N 500 -780 510 -780 {
lab=#net1}
N 380 -860 500 -860 {
lab=#net1}
N 200 -860 200 -800 {
lab=#net2}
N 190 -800 200 -800 {
lab=#net2}
N 500 -860 500 -800 {
lab=#net1}
N 490 -800 500 -800 {
lab=#net1}
N 200 -1200 200 -860 {
lab=#net2}
N 200 -860 320 -860 {
lab=#net2}
N 350 -1230 350 -1150 {
lab=vctrl}
N 350 -1230 460 -1230 {
lab=vctrl}
N 240 -1230 350 -1230 {
lab=vctrl}
N 200 -1330 200 -1230 {
lab=vdd}
N 200 -1330 500 -1330 {
lab=vdd}
N 740 -1330 740 -1230 {
lab=vdd}
N 500 -1330 740 -1330 {
lab=vdd}
N 500 -1330 500 -1230 {
lab=vdd}
N 740 -930 740 -740 {
lab=vref}
N 510 -790 570 -790 {
lab=#net1}
N 510 -800 510 -790 {
lab=#net1}
N 130 -790 190 -790 {
lab=#net2}
N 190 -800 190 -790 {
lab=#net2}
N 740 -930 780 -930 {
lab=vref}
N 740 -1200 740 -930 {
lab=vref}
N 570 -1230 700 -1230 {
lab=vctrl}
N 500 -130 500 -20 {
lab=vss}
N 200 -210 200 -20 {
lab=vss}
N 500 -20 740 -20 {
lab=vss}
N 670 -700 720 -700 {
lab=vss}
N 740 -660 740 -20 {
lab=vss}
N 960 -20 1020 -20 {
lab=vss}
N 740 -20 960 -20 {
lab=vss}
N 480 -20 500 -20 {
lab=vss}
N 500 -1200 500 -1130 {
lab=#net3}
N 500 -780 500 -750 {
lab=#net1}
N 490 -780 500 -780 {
lab=#net1}
N 390 -790 390 -750 {
lab=#net1}
N 200 -780 200 -750 {
lab=#net2}
N 190 -780 200 -780 {
lab=#net2}
N 200 -690 200 -290 {
lab=#net4}
N 310 -790 310 -750 {
lab=#net2}
N 1060 -890 1060 -820 {
lab=VBE}
N 1060 -740 1060 -700 {
lab=vss}
N 1060 -700 1120 -700 {
lab=vss}
N 1060 -1030 1060 -1000 {
lab=vdd}
N 1060 -1030 1110 -1030 {
lab=vdd}
N 1060 -890 1090 -890 {
lab=VBE}
N 1060 -940 1060 -890 {
lab=VBE}
N 1100 -790 1120 -790 {
lab=vss}
N 1120 -790 1120 -740 {
lab=vss}
N 1060 -740 1120 -740 {
lab=vss}
N 1060 -760 1060 -740 {
lab=vss}
N 1310 -1100 1370 -1100 {
lab=#net5}
N 1310 -1080 1370 -1080 {
lab=#net5}
N 1410 -1150 1410 -1130 {
lab=vdd}
N 1380 -1150 1410 -1150 {
lab=vdd}
N 1410 -1050 1410 -1030 {
lab=vss}
N 1380 -1030 1410 -1030 {
lab=vss}
N 1460 -1090 1510 -1090 {
lab=#net6}
N 500 -520 500 -370 {
lab=#net7}
N 350 -300 370 -300 {
lab=vss}
N 330 -300 350 -300 {
lab=vss}
N 350 -420 370 -420 {
lab=vss}
N 330 -420 350 -420 {
lab=vss}
N 350 -420 350 -300 {
lab=vss}
N 350 -580 350 -420 {
lab=vss}
N 500 -520 580 -520 {
lab=#net7}
N 500 -600 580 -600 {
lab=#net7}
N 310 -690 310 -460 {
lab=#net8}
N 390 -690 390 -460 {
lab=#net9}
N 500 -690 500 -600 {
lab=#net7}
N 500 -290 500 -210 {
lab=#net10}
N 480 -330 480 -20 {
lab=vss}
N 390 -20 480 -20 {
lab=vss}
N 350 -300 350 -20 {
lab=vss}
N 310 -260 310 -20 {
lab=vss}
N 200 -20 310 -20 {
lab=vss}
N 390 -260 390 -20 {
lab=vss}
N 350 -20 390 -20 {
lab=vss}
N 310 -20 350 -20 {
lab=vss}
N 500 -1070 500 -860 {
lab=#net1}
N 320 -860 380 -890 {
lab=#net2}
N 320 -890 380 -860 {
lab=#net1}
N 250 -1050 250 -1000 {
lab=vdd}
N 250 -1050 290 -1050 {
lab=vdd}
N 450 -1050 450 -1000 {
lab=vss}
N 410 -1050 450 -1050 {
lab=vss}
N 940 -1450 980 -1450 {
lab=y}
N 890 -1530 890 -1490 {
lab=vss}
N 910 -1530 910 -1490 {
lab=B}
N 850 -1450 880 -1450 {
lab=#net11}
N 980 -1390 1050 -1390 {
lab=vss}
N 1690 -760 1690 -690 {
lab=#net12}
N 1690 -690 1850 -690 {
lab=#net12}
N 1690 -910 1840 -910 {
lab=A}
N 1690 -910 1690 -840 {
lab=A}
N 1600 -910 1690 -910 {
lab=A}
N 1940 -700 2020 -700 {
lab=#net13}
N 2310 -790 2310 -700 {
lab=#net14}
N 1840 -790 2310 -790 {
lab=#net14}
N 1840 -890 1840 -790 {
lab=#net14}
N 1930 -900 1990 -900 {
lab=#net15}
N 2300 -900 2300 -760 {
lab=#net16}
N 1850 -760 2300 -760 {
lab=#net16}
N 1850 -760 1850 -710 {
lab=#net16}
N 1310 -1100 1310 -1080 {
lab=#net5}
N 2300 -900 2320 -900 {
lab=#net16}
N 2060 -680 2060 -630 {
lab=vss}
N 2100 -700 2310 -700 {
lab=#net14}
N 2060 -630 2210 -630 {
lab=vss}
N 2030 -880 2030 -830 {
lab=vss}
N 2070 -900 2300 -900 {
lab=#net16}
N 2030 -830 2180 -830 {
lab=vss}
N 2310 -700 2330 -700 {
lab=#net14}
N 2400 -900 2560 -900 {
lab=clk1}
N 2490 -700 2530 -700 {
lab=clk2}
N 2450 -660 2450 -630 {
lab=vss}
N 2450 -630 2510 -630 {
lab=vss}
N 2360 -860 2360 -830 {
lab=vss}
N 2360 -830 2480 -830 {
lab=vss}
N 480 -330 520 -330 {lab=vss}
N 480 -560 480 -330 {
lab=vss}
N 500 -370 540 -370 {lab=#net7}
N 500 -290 540 -290 {lab=#net10}
N 500 -600 500 -520 {lab=#net7}
N 390 -380 390 -340 {lab=#net17}
N 310 -380 310 -340 {lab=#net18}
N 570 -2850 770 -2850 {
lab=#net19}
N 810 -2900 810 -2880 {
lab=#net20}
N 330 -2850 330 -2800 {
lab=#net19}
N 620 -2830 620 -2800 {
lab=snk_cap}
N 620 -2830 770 -2830 {
lab=snk_cap}
N 560 -2780 560 -2760 {
lab=#net21}
N 600 -2800 620 -2800 {
lab=snk_cap}
N 460 -2800 520 -2800 {
lab=#net22}
N 330 -2800 380 -2800 {
lab=#net19}
N 420 -2760 460 -2760 {
lab=vss}
N 420 -2840 460 -2840 {
lab=vdd}
N 300 -2850 330 -2850 {
lab=#net19}
N 650 -2900 650 -2890 {
lab=#net20}
N 680 -2900 810 -2900 {
lab=#net20}
N 570 -2860 610 -2860 {
lab=#net19}
N 570 -2860 570 -2850 {
lab=#net19}
N 330 -2850 570 -2850 {
lab=#net19}
N 650 -2860 680 -2860 {
lab=#net20}
N 680 -2900 680 -2860 {
lab=#net20}
N 650 -2900 680 -2900 {
lab=#net20}
N 180 -2840 210 -2840 {lab=#net23}
N 180 -2860 210 -2860 {lab=#net24}
N 860 -2840 910 -2840 {lab=pulseOut}
N 3350 -1080 3450 -1080 {lab=cmp}
N 3450 -1080 3450 -980 {lab=cmp}
N 3450 -1160 3450 -1080 {lab=cmp}
N 3820 -1160 3970 -1160 {
lab=src_gate}
N 3855 -1040 3860 -1040 {
lab=vss}
N 3860 -1120 3875 -1120 {
lab=vdd}
N 3780 -1160 3780 -1080 {
lab=src_gate}
N 3780 -1080 3820 -1080 {
lab=src_gate}
N 3900 -1080 4150 -1080 {
lab=src_gate_n}
N 3600 -1220 3600 -1200 {lab=src_n}
N 3570 -1220 3600 -1220 {lab=src_n}
N 3650 -1160 3780 -1160 {lab=src_gate}
N 3820 -1190 3820 -1160 {lab=src_gate}
N 3780 -1160 3820 -1160 {
lab=src_gate}
N 3820 -1290 3820 -1220 {lab=vdd}
N 3820 -1290 3860 -1290 {lab=vdd}
N 3600 -1220 3780 -1220 {lab=src_n}
N 3610 -1040 3610 -1020 {lab=snk}
N 3580 -1040 3610 -1040 {lab=snk}
N 3770 -980 4030 -980 {lab=snk_gate_n}
N 3450 -1160 3550 -1160 {lab=cmp}
N 3450 -980 3560 -980 {lab=cmp}
N 3770 -980 3770 -890 {lab=snk_gate_n}
N 3660 -980 3770 -980 {lab=snk_gate_n}
N 3770 -860 3770 -830 {lab=vss}
N 3700 -860 3730 -860 {lab=#net25}
N 3970 -1220 3970 -1160 {lab=src_gate}
N 4110 -980 4190 -980 {lab=snk_gate}
N 4150 -1220 4150 -1080 {lab=src_gate_n}
N 4150 -1220 4190 -1220 {lab=src_gate_n}
N 4190 -1040 4190 -980 {lab=snk_gate}
N 6270 -3500 6270 -3440 {
lab=#net26}
N 6270 -2330 6270 -2290 {
lab=#net27}
N 6180 -3440 6230 -3440 {
lab=pbias}
N 6200 -2330 6230 -2330 {
lab=nbias}
N 7430 -2320 7510 -2320 {
lab=Vpre}
N 6270 -2870 6270 -2750 {
lab=#net28}
N 6450 -3020 6450 -3000 {
lab=vss}
N 6450 -3000 6510 -3000 {
lab=vss}
N 6490 -3050 6515 -3050 {
lab=src_gate}
N 6380 -2650 6380 -2630 {
lab=vdd}
N 6380 -2650 6430 -2650 {
lab=vdd}
N 6420 -2600 6470 -2600 {
lab=snk_gate_n}
N 6270 -2380 6270 -2350 {
lab=#net29}
N 6270 -3410 6270 -3370 {
lab=#net30}
N 7430 -2070 7430 -1990 {
lab=vss}
N 7470 -2070 7540 -2070 {
lab=preChrg}
N 7430 -2130 7430 -2100 {
lab=#net31}
N 7430 -2220 7430 -2190 {
lab=#net32}
N 7430 -1990 7500 -1990 {
lab=vss}
N 7410 -1990 7430 -1990 {
lab=vss}
N 7430 -2700 7430 -2670 {
lab=#net33}
N 7430 -2830 7430 -2780 {
lab=vdd}
N 7430 -2830 7490 -2830 {
lab=vdd}
N 7430 -2590 7430 -2560 {
lab=#net34}
N 6270 -3270 6450 -3270 {
lab=#net35}
N 6180 -2290 6270 -2290 {
lab=#net27}
N 6270 -3050 6450 -3050 {
lab=vdd}
N 6270 -2600 6380 -2600 {
lab=vss}
N 6270 -2470 6270 -2440 {
lab=#net36}
N 6380 -2570 6380 -2470 {
lab=#net36}
N 6270 -2470 6380 -2470 {
lab=#net36}
N 6270 -2570 6270 -2470 {
lab=#net36}
N 6450 -3270 6450 -3080 {
lab=#net35}
N 6610 -3275 6610 -3210 {
lab=#net37}
N 6610 -3150 6610 -2870 {
lab=#net28}
N 6680 -2870 6760 -2870 {
lab=#net28}
N 6820 -2870 6910 -2870 {
lab=vctrl}
N 6610 -3380 6610 -3345 {
lab=#net38}
N 6610 -3500 6610 -3440 {
lab=#net26}
N 6270 -3270 6270 -3220 {
lab=#net35}
N 6270 -3160 6270 -3080 {
lab=#net39}
N 6720 -2660 6810 -2660 {
lab=preChrg}
N 6665 -2660 6680 -2660 {
lab=vss}
N 6680 -2870 6680 -2750 {
lab=#net28}
N 7430 -2320 7430 -2300 {lab=Vpre}
N 7410 -2260 7410 -1990 {
lab=vss}
N 7430 -2300 7460 -2300 {lab=Vpre}
N 7430 -2220 7460 -2220 {lab=#net32}
N 7410 -2260 7440 -2260 {lab=vss}
N 7430 -2370 7430 -2320 {lab=Vpre}
N 7430 -2480 7430 -2450 {lab=#net40}
N 7410 -2740 7410 -2260 {
lab=vss}
N 6680 -2470 6680 -2410 {lab=vss}
N 6680 -2410 6710 -2410 {lab=vss}
N 7990 -2030 8080 -2030 {
lab=nbias}
N 7990 -2030 7990 -2010 {
lab=nbias}
N 8200 -2360 8200 -2330 {
lab=pbias}
N 8110 -2330 8200 -2330 {
lab=pbias}
N 8110 -2390 8110 -2330 {
lab=pbias}
N 8110 -2390 8160 -2390 {
lab=pbias}
N 8200 -2450 8200 -2390 {
lab=vdd}
N 7990 -1980 7990 -1930 {
lab=vss}
N 7930 -1930 7990 -1930 {
lab=vss}
N 8080 -2030 8080 -1980 {
lab=nbias}
N 8030 -1980 8080 -1980 {
lab=nbias}
N 8200 -1980 8200 -1930 {
lab=vss}
N 8080 -1980 8160 -1980 {
lab=nbias}
N 8200 -2330 8200 -2300 {
lab=pbias}
N 7930 -2530 7970 -2530 {
lab=vss}
N 7990 -2770 7990 -2730 {
lab=vdd}
N 7930 -2610 7930 -2530 {
lab=vss}
N 7930 -2530 7930 -1930 {
lab=vss}
N 7990 -1930 8200 -1930 {
lab=vss}
N 7930 -2610 7970 -2610 {
lab=vss}
N 7930 -2690 7930 -2610 {
lab=vss}
N 7990 -2050 7990 -2030 {lab=nbias}
N 8200 -2240 8200 -2010 {lab=#net41}
N 7990 -2490 7990 -2290 {lab=ncasc}
N 7990 -2290 8080 -2290 {lab=ncasc}
N 8080 -2290 8080 -2230 {lab=ncasc}
N 7990 -2290 7990 -2260 {lab=ncasc}
N 8030 -2230 8080 -2230 {lab=ncasc}
N 7990 -2200 7990 -2110 {lab=#net42}
N 7930 -2690 7970 -2690 {lab=vss}
N 5390 -2840 5490 -2840 {lab=cmp}
N 5490 -2840 5490 -2600 {lab=cmp}
N 5490 -3050 5490 -2840 {lab=cmp}
N 5640 -3110 5640 -3090 {lab=src_n}
N 5610 -3110 5640 -3110 {lab=src_n}
N 5930 -3050 6000 -3050 {lab=src_gate}
N 5650 -2660 5650 -2640 {lab=snk}
N 5490 -3050 5590 -3050 {lab=cmp}
N 5490 -2600 5600 -2600 {lab=cmp}
N 5930 -2950 5930 -2920 {lab=vss}
N 5860 -2950 5890 -2950 {lab=#net43}
N 6010 -2600 6230 -2600 {lab=snk_gate}
N 5760 -2730 5760 -2660 {lab=vdd}
N 5760 -2730 5800 -2730 {lab=vdd}
N 5650 -2660 5720 -2660 {lab=snk}
N 5760 -2630 5760 -2600 {lab=snk_gate_n}
N 5700 -2600 5760 -2600 {lab=snk_gate_n}
N 5760 -2600 5930 -2600 {lab=snk_gate_n}
N 6080 -3050 6230 -3050 {lab=src_gate_n}
N 5930 -3050 5930 -2980 {lab=src_gate}
N 5690 -3050 5930 -3050 {lab=src_gate}
N 6270 -2870 6610 -2870 {lab=#net28}
N 6270 -3020 6270 -2870 {
lab=#net28}
N 6610 -2870 6680 -2870 {lab=#net28}
N 6270 -2690 6270 -2630 {lab=#net44}
N 6270 -3500 6610 -3500 {lab=#net26}
N 6180 -3500 6270 -3500 {lab=#net26}
N 6270 -3310 6270 -3270 {lab=#net35}
N 6680 -2630 6680 -2580 {lab=Vpre}
N 2820 260 2820 300 {lab=vp}
N 2720 260 2820 260 {lab=vp}
N 2540 260 2540 290 {lab=#net45}
N 2540 260 2620 260 {lab=#net45}
N 2540 360 2540 400 {lab=vss}
N 2700 400 2820 400 {lab=vss}
N 2820 370 2820 400 {lab=vss}
N 2700 310 2700 400 {lab=vss}
N 2540 400 2700 400 {lab=vss}
N 2670 170 2670 220 {lab=B}
N 2620 170 2670 170 {lab=B}
N 3630 -170 3680 -170 {lab=#net46}
N 3590 -170 3590 -90 {lab=#net46}
N 3590 -90 3680 -90 {lab=#net46}
N 3810 -170 3850 -170 {lab=#net47}
N 3850 -170 3850 -90 {lab=#net47}
N 3760 -90 3850 -90 {lab=#net47}
N 3630 -210 3630 -170 {lab=#net46}
N 3590 -170 3630 -170 {lab=#net46}
N 3810 -210 3810 -170 {lab=#net47}
N 3760 -170 3810 -170 {lab=#net47}
N 3630 -310 3630 -270 {lab=#net48}
N 3630 -310 3810 -310 {lab=#net48}
N 3810 -310 3810 -270 {lab=#net48}
N 3170 -320 3370 -320 {
lab=cmp}
N 3410 -370 3410 -350 {
lab=vdd}
N 2930 -320 2930 -270 {
lab=cmp}
N 3220 -300 3220 -270 {
lab=#net49}
N 3280 -300 3370 -300 {
lab=#net49}
N 3200 -270 3220 -270 {
lab=#net49}
N 3060 -270 3120 -270 {
lab=#net50}
N 2930 -270 2980 -270 {
lab=cmp}
N 3250 -370 3250 -360 {
lab=vdd}
N 3280 -370 3410 -370 {
lab=vdd}
N 3170 -330 3210 -330 {
lab=cmp}
N 3170 -330 3170 -320 {
lab=cmp}
N 2930 -320 3170 -320 {
lab=cmp}
N 3250 -330 3280 -330 {
lab=vdd}
N 3280 -370 3280 -330 {
lab=vdd}
N 3250 -370 3280 -370 {
lab=vdd}
N 3460 -310 3630 -310 {lab=#net48}
N 3280 -300 3280 -280 {lab=#net49}
N 3220 -300 3280 -300 {
lab=#net49}
N 3160 -250 3160 -210 {lab=vss}
N 3160 -210 3280 -210 {lab=vss}
N 3970 -2960 3980 -2960 {lab=vin}
N 3710 -2960 3730 -2960 {lab=vref}
N 3790 -2960 3840 -2960 {lab=#net51}
N 3710 -2960 3710 -2770 {lab=vref}
N 3680 -2960 3710 -2960 {lab=vref}
N 3710 -2710 3710 -2590 {lab=#net52}
N 3710 -2590 3970 -2590 {lab=#net52}
N 3970 -2770 3970 -2590 {lab=#net52}
N 3970 -2960 3970 -2870 {lab=vin}
N 3940 -2960 3970 -2960 {lab=vin}
N 4330 -2960 4380 -2960 {lab=#net53}
N 4220 -2960 4270 -2960 {lab=vref}
N 4480 -2960 4520 -2960 {lab=vin}
N 2390 -2660 2440 -2660 {lab=B}
N 2390 -2600 2440 -2600 {lab=vn}
N 2720 -2630 2760 -2630 {lab=vn}
N 2390 -2600 2390 -2480 {lab=vn}
N 2390 -2480 2720 -2480 {lab=vn}
N 2720 -2630 2720 -2480 {lab=vn}
N 2700 -2630 2720 -2630 {lab=vn}
N 2530 -3080 2530 -3050 {lab=vss}
N 2530 -3130 2530 -3100 {lab=vdd}
N 2948 -2627 2950 -2620 {lab=vdd}
N 2720 -2710 2870 -2710 {lab=#net57}
N 3130 -2740 3180 -2740 {lab=vp}
N 640 -2360 640 -2240 {lab=CMPoff2}
N 1000 -2360 1000 -2240 {lab=inm}
N 820 -2360 960 -2360 {lab=vdd}
N 830 -2300 960 -2300 {lab=vdd}
N 820 -2240 960 -2240 {lab=vdd}
N 680 -2360 820 -2360 {lab=vdd}
N 820 -2290 820 -2240 {lab=vdd}
N 680 -2240 820 -2240 {lab=vdd}
N 830 -2310 830 -2300 {lab=vdd}
N 820 -2310 830 -2310 {lab=vdd}
N 810 -2300 810 -2290 {lab=vdd}
N 820 -2290 830 -2290 {lab=vdd}
N 830 -2300 830 -2290 {lab=vdd}
N 810 -2310 810 -2300 {lab=vdd}
N 680 -2300 810 -2300 {lab=vdd}
N 810 -2310 820 -2310 {lab=vdd}
N 820 -2360 820 -2310 {lab=vdd}
N 810 -2290 820 -2290 {lab=vdd}
N 11960 -2410 11960 -2140 {
lab=outRes}
N 11810 -2530 11810 -2450 {
lab=PA}
N 12110 -2360 12110 -2320 {
lab=vss}
N 12110 -2490 12110 -2450 {
lab=vdd}
N 12080 -2530 12080 -2450 {
lab=PA}
N 12380 -2240 12400 -2240 {
lab=PB}
N 12650 -2240 12750 -2240 {
lab=PC}
N 12770 -2520 12770 -2450 {
lab=PD}
N 13070 -2410 13070 -2140 {
lab=vref}
N 11130 -2200 11170 -2200 {
lab=vdd}
N 11550 -2230 11610 -2230 {
lab=PI1}
N 11550 -2200 11590 -2200 {
lab=vdd}
N 11260 -2200 11460 -2200 {
lab=vss}
N 11500 -2050 11500 -2040 {
lab=vpm}
N 11510 -2060 11520 -2060 {
lab=vpm}
N 11220 -2050 11220 -2040 {
lab=vnm}
N 11210 -2060 11220 -2060 {
lab=vnm}
N 11740 -2050 11790 -2050 {
lab=vp}
N 11740 -2050 11740 -1950 {
lab=vp}
N 11220 -2060 11220 -2050 {
lab=vnm}
N 11500 -2060 11500 -2050 {
lab=vpm}
N 11210 -2040 11220 -2040 {
lab=vnm}
N 11220 -2050 11310 -2050 {
lab=vnm}
N 10930 -2050 10980 -2050 {
lab=vn}
N 10980 -2050 10980 -1950 {
lab=vn}
N 10980 -1880 10980 -1220 {
lab=vss}
N 12610 -1220 13070 -1220 {
lab=vss}
N 13070 -2070 13070 -1220 {
lab=vss}
N 12610 -2070 12610 -1220 {
lab=vss}
N 12440 -1220 12610 -1220 {
lab=vss}
N 12440 -2070 12440 -1220 {
lab=vss}
N 11740 -1880 11740 -1220 {
lab=vss}
N 11510 -1220 11740 -1220 {
lab=vss}
N 12240 -1220 12440 -1220 {
lab=vss}
N 11510 -1340 11510 -1220 {
lab=vss}
N 11210 -1340 11210 -1220 {
lab=vss}
N 10980 -1220 11210 -1220 {
lab=vss}
N 11170 -1390 11170 -1340 {
lab=vss}
N 11170 -1340 11210 -1340 {
lab=vss}
N 11550 -1390 11550 -1340 {
lab=vss}
N 11510 -1340 11550 -1340 {
lab=vss}
N 11510 -1360 11510 -1340 {
lab=vss}
N 11240 -2630 11320 -2630 {
lab=vctrl}
N 11360 -2730 11360 -2630 {
lab=vdd}
N 13070 -2410 13100 -2410 {
lab=vref}
N 11960 -2530 12080 -2530 {
lab=PA}
N 11960 -2560 11960 -2530 {
lab=PA}
N 11810 -2530 11960 -2530 {
lab=PA}
N 11080 -2230 11170 -2230 {
lab=PII1}
N 10730 -2320 10770 -2320 {
lab=dummy}
N 10770 -2320 10770 -2280 {
lab=dummy}
N 10790 -2240 10790 -2200 {
lab=vss}
N 10730 -2200 10790 -2200 {
lab=vss}
N 11210 -1360 11210 -1340 {
lab=vss}
N 11390 -2050 11500 -2050 {
lab=vpm}
N 11510 -2040 11520 -2040 {
lab=vpm}
N 11490 -1220 11510 -1220 {
lab=vss}
N 11360 -2600 11360 -2550 {
lab=pmosDrain}
N 11360 -2420 11360 -2410 {
lab=cascDrain}
N 11210 -2410 11360 -2410 {
lab=cascDrain}
N 11510 -2040 11510 -2010 {
lab=vpm}
N 11500 -2040 11510 -2040 {
lab=vpm}
N 11510 -1510 11510 -1420 {
lab=Vbe1}
N 11310 -1220 11350 -1220 {
lab=vss}
N 11390 -1220 11490 -1220 {
lab=vss}
N 11510 -1950 11510 -1590 {
lab=#net1}
N 11960 -2410 12030 -2410 {
lab=outRes}
N 11510 -2410 11760 -2410 {
lab=cascDrain}
N 11510 -2180 11510 -2060 {
lab=vpm}
N 11500 -2060 11510 -2060 {
lab=vpm}
N 11200 -2050 11200 -2040 {
lab=vnm}
N 11210 -2180 11210 -2060 {
lab=vnm}
N 11200 -2060 11210 -2060 {
lab=vnm}
N 12440 -2410 12440 -2290 {
lab=topSw}
N 12440 -2190 12440 -2140 {
lab=Hcharge}
N 12610 -2410 12610 -2290 {
lab=topSw}
N 12440 -2410 12610 -2410 {
lab=topSw}
N 12610 -2190 12610 -2140 {
lab=Lcharge}
N 12490 -2270 12560 -2270 {
lab=vss}
N 12950 -2520 12950 -2500 {
lab=PD}
N 12770 -2520 12950 -2520 {
lab=PD}
N 12770 -2580 12770 -2520 {
lab=PD}
N 12920 -2460 12920 -2410 {
lab=vref}
N 12980 -2410 13070 -2410 {
lab=vref}
N 12980 -2460 12980 -2410 {
lab=vref}
N 12950 -2210 12950 -2170 {
lab=PD}
N 12920 -2410 12920 -2360 {
lab=vref}
N 12980 -2410 12980 -2360 {
lab=vref}
N 12950 -2320 12950 -2290 {
lab=#net2}
N 12610 -2410 12740 -2410 {
lab=topSw}
N 11310 -2050 11310 -2010 {
lab=vnm}
N 11390 -2050 11390 -2010 {
lab=vpm}
N 11210 -2040 11210 -2010 {
lab=vnm}
N 11200 -2040 11210 -2040 {
lab=vnm}
N 11210 -1950 11210 -1420 {
lab=Vbe2}
N 11490 -1550 11490 -1220 {
lab=vss}
N 12130 -2410 12440 -2410 {
lab=topSw}
N 11860 -2410 11960 -2410 {
lab=outRes}
N 12240 -1400 12240 -1340 {
lab=topSw}
N 12240 -1310 12240 -1220 {
lab=vss}
N 11510 -2300 11510 -2280 {lab=#net3}
N 11510 -2410 11510 -2360 {lab=cascDrain}
N 11360 -2410 11510 -2410 {
lab=cascDrain}
N 11210 -2410 11210 -2380 {lab=cascDrain}
N 11210 -2320 11210 -2280 {lab=#net4}
N 11490 -1550 11530 -1550 {lab=vss}
N 11510 -1590 11550 -1590 {lab=#net1}
N 11510 -1510 11550 -1510 {lab=Vbe1}
N 11350 -1490 11370 -1490 {lab=vss}
N 11350 -1490 11350 -1220 {lab=vss}
N 11330 -1490 11350 -1490 {lab=vss}
N 11940 -1980 11940 -1220 {lab=vss}
N 11960 -1220 12240 -1220 {
lab=vss}
N 11940 -1980 12060 -1980 {lab=vss}
N 11940 -2100 11940 -1980 {lab=vss}
N 11960 -2020 12040 -2020 {lab=#net5}
N 11960 -2060 11960 -2020 {lab=#net5}
N 11960 -1940 12040 -1940 {lab=vss}
N 11960 -1940 11960 -1220 {lab=vss}
N 11940 -1220 11960 -1220 {
lab=vss}
N 10980 -2860 10980 -2800 {lab=vdd}
N 10980 -2860 11020 -2860 {lab=vdd}
N 10980 -2610 10980 -2580 {lab=#net6}
N 10880 -2800 10940 -2800 {lab=vctrl}
N 10980 -2550 10980 -2470 {lab=vss}
N 10920 -2550 10940 -2550 {lab=#net6}
N 10770 -2550 10770 -2470 {lab=vss}
N 10770 -2650 10770 -2580 {lab=pcasc}
N 10770 -2860 10770 -2700 {lab=vdd}
N 10770 -2860 10980 -2860 {lab=vdd}
N 10830 -2700 10860 -2700 {lab=pcasc}
N 10920 -2610 10980 -2610 {lab=#net6}
N 10980 -2670 10980 -2610 {lab=#net6}
N 10920 -2610 10920 -2550 {lab=#net6}
N 10810 -2550 10920 -2550 {lab=#net6}
N 10830 -2700 10830 -2650 {lab=pcasc}
N 10770 -2650 10830 -2650 {lab=pcasc}
N 10810 -2700 10830 -2700 {lab=pcasc}
N 10770 -2670 10770 -2650 {lab=pcasc}
N 11360 -2520 11390 -2520 {lab=vdd}
N 11270 -2520 11320 -2520 {lab=pcasc}
N 10980 -2770 10980 -2730 {lab=#net7}
N 10770 -2470 10980 -2470 {lab=vss}
N 11360 -2490 11360 -2480 {lab=#net8}
N 11310 -1670 11310 -1530 {lab=#net9}
N 11310 -1950 11310 -1750 {lab=#net10}
N 11390 -1950 11390 -1750 {lab=#net11}
N 11390 -1670 11390 -1530 {lab=#net12}
N 11350 -1710 11450 -1710 {lab=vss}
N 11390 -1750 11430 -1750 {lab=#net11}
N 11390 -1670 11430 -1670 {lab=#net12}
N 11250 -1710 11350 -1710 {lab=vss}
N 11270 -1670 11310 -1670 {lab=#net9}
N 11350 -1710 11350 -1490 {lab=vss}
N 11270 -1750 11310 -1750 {lab=#net10}
N 11210 -1220 11310 -1220 {
lab=vss}
N 11350 -1220 11390 -1220 {
lab=vss}
N 11390 -1450 11390 -1220 {lab=vss}
N 11310 -1450 11310 -1220 {lab=vss}
N 12820 -2410 12920 -2410 {
lab=vref}
N 12920 -2410 12980 -2410 {
lab=vref}
N 11520 -2050 11520 -2040 {
lab=vpm}
N 11800 -1370 11800 -1330 {lab=vp}
N 11800 -1220 11940 -1220 {
lab=vss}
N 11740 -1220 11800 -1220 {
lab=vss}
N 10920 -1410 10920 -1370 {lab=vn}
N 10920 -1220 10980 -1220 {lab=vss}
N 11520 -2050 11580 -2050 {lab=vpm}
N 11520 -2060 11520 -2050 {
lab=vpm}
N 11630 -2130 11630 -2090 {lab=PI2}
N 11680 -2050 11740 -2050 {lab=vp}
N 10980 -2050 11040 -2050 {lab=vn}
N 11140 -2050 11200 -2050 {lab=vnm}
N 11200 -2060 11200 -2050 {
lab=vnm}
N 11090 -2130 11090 -2090 {lab=PII2}
N 11800 -1300 11800 -1220 {lab=vss}
N 10920 -1340 10920 -1220 {lab=vss}
N 9610 -1340 9690 -1340 {lab=vss}
N 9610 -1460 9610 -1340 {lab=vss}
N 9630 -1380 9710 -1380 {lab=#net9}
N 9630 -1420 9630 -1380 {lab=#net9}
N 9630 -1300 9710 -1300 {lab=vss}
N 9630 -1770 9630 -1500 {lab=outRes}
N 9470 -1340 9610 -1340 {lab=vss}
N 9470 -1460 9470 -1340 {lab=vss}
N 9490 -1380 9570 -1380 {lab=#net10}
N 9490 -1420 9490 -1380 {lab=#net10}
N 9490 -1300 9570 -1300 {lab=vss}
N 9490 -1770 9490 -1500 {lab=outRes}
N 9470 -1340 9470 -580 {lab=vss}
N 9490 -1300 9490 -580 {lab=vss}
N 9630 -1300 9630 -580 {lab=vss}
N 1970 -1980 1980 -1980 {lab=vin}
N 1710 -1980 1730 -1980 {lab=OTAvip}
N 1790 -1980 1840 -1980 {lab=#net4}
N 1710 -1980 1710 -1790 {lab=OTAvip}
N 1710 -1730 1710 -1610 {lab=OTAout}
N 1710 -1610 1970 -1610 {lab=OTAout}
N 1970 -1790 1970 -1610 {lab=OTAout}
N 1970 -1980 1970 -1890 {lab=vin}
N 1940 -1980 1970 -1980 {lab=vin}
N 1890 -2040 1890 -2020 {lab=#net5}
N 1630 -1980 1710 -1980 {lab=OTAvip}
N 9000 -830 9120 -830 {lab=Vbe1}
N 8790 -990 8830 -990 {lab=#net8}
N 8980 -870 9100 -870 {lab=vss}
N 8750 -950 8860 -950 {lab=#net9}
N 8750 -1030 8750 -950 {lab=#net9}
N 8880 -990 8920 -990 {lab=#net10}
N 8750 -1030 8900 -1030 {lab=#net9}
N 8670 -990 8710 -990 {lab=#net11}
N 8580 -990 8620 -990 {lab=#net13}
N 8600 -1030 8750 -1030 {lab=#net9}
N 8640 -950 8750 -950 {lab=#net9}
N 9000 -910 9120 -910 {lab=#net14}
N 8580 -1070 8710 -1070 {lab=#net12}
N 8790 -1070 8920 -1070 {lab=#net7}
N 8620 -910 8710 -910 {lab=#net16}
N 8790 -910 8880 -910 {lab=#net15}
N 6770 -620 6820 -620 {lab=ip_intermediate}
N 6860 -680 7030 -680 {lab=vdd}
N 6860 -680 6860 -650 {lab=vdd}
N 7030 -680 7030 -650 {lab=vdd}
N 6900 -420 6990 -420 {lab=nbias}
N 7070 -620 7110 -620 {lab=in_intermediate}
N 7030 -420 7030 -360 {lab=vss}
N 6860 -360 7030 -360 {lab=vss}
N 6860 -420 6860 -360 {lab=vss}
N 6790 -550 6860 -550 {lab=ipShifted}
N 7030 -550 7090 -550 {lab=inShifted}
N 7030 -590 7030 -550 {lab=inShifted}
N 6860 -590 6860 -550 {lab=ipShifted}
N 7030 -550 7030 -530 {lab=inShifted}
N 7030 -470 7030 -450 {lab=#net9}
N 6860 -550 6860 -530 {lab=ipShifted}
N 6860 -470 6860 -450 {lab=#net10}
N 6470 -690 6620 -690 {lab=vdd}
N 6470 -690 6470 -620 {lab=vdd}
N 6620 -690 6620 -620 {lab=vdd}
N 6510 -620 6580 -620 {lab=pbias}
N 6470 -590 6470 -550 {lab=ip_intermediate}
N 6620 -590 6620 -550 {lab=in_intermediate}
N 6530 -520 6580 -520 {lab=in}
N 6390 -520 6430 -520 {lab=ip}
N 6470 -460 6620 -460 {lab=#net13}
N 6470 -490 6470 -460 {lab=#net13}
N 6620 -490 6620 -460 {lab=#net13}
C {devices/ipin.sym} 120 -1010 0 0 {name=p4 lab=vss}
C {devices/ipin.sym} 120 -1040 0 0 {name=p5 lab=vdd}
C {devices/lab_wire.sym} 1140 -180 0 0 {name=p32 sig_type=std_logic lab=pbias}
C {devices/lab_wire.sym} 960 -500 0 0 {name=p34 sig_type=std_logic lab=vdd}
C {JNW_ATR_SKY130A/JNWATR_PCH_8C5F0.sym} 1140 -240 0 0 {name=x7 }
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 920 -70 0 0 {name=x28 }
C {devices/lab_wire.sym} 930 -120 0 0 {name=p12 sig_type=std_logic lab=nbias}
C {devices/lab_wire.sym} 1180 -300 0 0 {name=p13 sig_type=std_logic lab=vdd}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 1140 -70 0 0 {name=x4 }
C {devices/lab_wire.sym} 1130 -70 0 0 {name=p14 sig_type=std_logic lab=nbias}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 960 -230 3 0 {name=x26 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 960 -310 3 0 {name=x27 }
C {JNW_TR_SKY130A/JNWTR_RPPO8.sym} 960 -390 3 0 {name=x11 }
C {sky130_fd_pr/pnp_05v5.sym} 520 -180 0 1 {name=Q1
model=pnp_05v5_W3p40L3p40
m=8
spiceprefix=X
}
C {sky130_fd_pr/pnp_05v5.sym} 220 -260 0 1 {name=Q2
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {devices/lab_wire.sym} 340 -1330 0 1 {name=p29 sig_type=std_logic lab=vdd

}
C {JNW_ATR_SKY130A/JNWATR_PCH_4C1F2.sym} 460 -1230 0 0 {name=x2 }
C {JNW_ATR_SKY130A/JNWATR_PCH_4C1F2.sym} 240 -1230 0 1 {name=x3 }
C {JNW_ATR_SKY130A/JNWATR_PCH_4C1F2.sym} 700 -1230 0 0 {name=x5 }
C {devices/lab_wire.sym} 340 -1230 0 1 {name=p8 sig_type=std_logic lab=vctrl

}
C {devices/lab_wire.sym} 620 -1230 0 1 {name=p9 sig_type=std_logic lab=vctrl

}
C {devices/lab_wire.sym} 620 -20 0 0 {name=p3 sig_type=std_logic lab=vss
}
C {devices/opin.sym} 780 -930 0 0 {name=p10 lab=vref}
C {devices/lab_wire.sym} 700 -700 0 0 {name=p11 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 740 -740 1 0 {name=x6 }
C {devices/vsource.sym} 500 -1100 0 0 {name=v_itot1 value=0 savecurrent=true}
C {devices/vsource.sym} 500 -720 0 0 {name=v_ip1 value=0 savecurrent=true}
C {devices/vsource.sym} 390 -720 0 0 {name=v_ip2 value=0 savecurrent=true}
C {devices/vsource.sym} 200 -720 0 0 {name=v_in1 value=0 savecurrent=true}
C {devices/vsource.sym} 310 -720 0 0 {name=v_in2 value=0 savecurrent=true}
C {devices/isource.sym} 1060 -970 0 0 {name=IVBE value=7u}
C {devices/lab_wire.sym} 1100 -1030 0 0 {name=p15 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 1110 -700 0 0 {name=p16 sig_type=std_logic lab=vss
}
C {devices/opin.sym} 1090 -890 0 0 {name=p17 lab=VBE}
C {sky130_fd_pr/pnp_05v5.sym} 1080 -790 0 1 {name=Q3
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {JNW_AVV_SKY130A/xor.sym} 1410 -1090 0 0 {name=x16}
C {devices/lab_wire.sym} 1410 -1150 0 0 {name=p20 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 1410 -1030 0 0 {name=p21 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 500 -370 1 0 {name=x18 }
C {JNW_AVV_SKY130A/OTA.sym} 350 -1000 3 0 {name=x1}
C {devices/lab_wire.sym} 260 -1050 0 1 {name=p1 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 440 -1050 0 0 {name=p2 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 890 -1520 0 0 {name=p6 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 910 -1530 0 0 {name=p24 sig_type=std_logic lab=B
}
C {devices/lab_wire.sym} 970 -1450 0 0 {name=p25 sig_type=std_logic lab=y
}
C {devices/switch_v_xyce.sym} 910 -1450 1 0 {.MODEL SWITCH1 SW(VT=0.5 VH=0.01 RON=0.01 ROFF=10000000)

name=S1 model=SWITCH1 state=OFF

}
C {devices/netlist.sym} 900 -1300 0 0 {name=s2 value=".MODEL SWITCH1 SW(VT=0.9 RON=1 ROFF=1000000000)"
}
C {devices/res.sym} 980 -1420 0 0 {name=R1
value=1k
footprint=1206
device=resistor
m=1}
C {devices/lab_wire.sym} 1040 -1390 0 0 {name=p22 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_NDX1_CV.sym} 1850 -690 0 0 {name=x13 }
C {devices/lab_wire.sym} 1890 -740 0 0 {name=p26 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 1890 -660 0 0 {name=p27 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_NDX1_CV.sym} 1840 -890 0 0 {name=x15 }
C {devices/lab_wire.sym} 1880 -940 0 0 {name=p28 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 1880 -860 0 0 {name=p30 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 1690 -840 1 0 {name=x17 }
C {devices/lab_wire.sym} 1650 -800 0 0 {name=p31 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 1730 -800 0 0 {name=p33 sig_type=std_logic lab=vdd}
C {devices/ipin.sym} 1600 -910 0 0 {name=p35 lab=A}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 1970 -1070 0 0 {name=x23 }
C {devices/lab_wire.sym} 2010 -1030 3 0 {name=p36 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 2010 -1110 3 0 {name=p37 sig_type=std_logic lab=vdd}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 2050 -1070 0 0 {name=x24 }
C {devices/lab_wire.sym} 2090 -1030 3 0 {name=p38 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 2090 -1110 3 0 {name=p39 sig_type=std_logic lab=vdd}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 2130 -1070 0 0 {name=x25 }
C {devices/lab_wire.sym} 2170 -1030 3 0 {name=p40 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 2170 -1110 3 0 {name=p41 sig_type=std_logic lab=vdd}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 2210 -1070 0 0 {name=x29 }
C {devices/lab_wire.sym} 2250 -1030 3 0 {name=p42 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 2250 -1110 3 0 {name=p43 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 2560 -900 0 0 {name=p53 sig_type=std_logic lab=clk1}
C {devices/lab_wire.sym} 2530 -700 0 0 {name=p54 sig_type=std_logic lab=clk2}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 2320 -900 0 0 {name=x34 }
C {devices/lab_wire.sym} 2360 -860 3 0 {name=p19 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 2360 -940 3 0 {name=p23 sig_type=std_logic lab=vdd}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 2210 -640 0 0 {name=x1[3:0]}
C {devices/lab_wire.sym} 2110 -630 3 0 {name=p45 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 2180 -840 0 0 {name=x2[3:0]}
C {devices/lab_wire.sym} 2080 -830 3 0 {name=p46 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 2330 -700 0 0 {name=x32 }
C {devices/lab_wire.sym} 2370 -660 3 0 {name=p47 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 2370 -740 3 0 {name=p48 sig_type=std_logic lab=vdd}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 2410 -700 0 0 {name=x35 }
C {devices/lab_wire.sym} 2450 -660 3 0 {name=p51 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 2450 -740 3 0 {name=p52 sig_type=std_logic lab=vdd}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 2480 -840 0 0 {name=x3[2:0]}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 2510 -640 0 0 {name=x4[2:0]}
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 2020 -700 0 0 {name=x31 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 1990 -900 0 0 {name=x30 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 540 -370 1 0 {name=x33 }
C {JNW_TR_SKY130A/JNWTR_RPPO8.sym} 390 -340 1 0 {name=x8 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 390 -460 1 0 {name=x9 }
C {JNW_TR_SKY130A/JNWTR_RPPO8.sym} 310 -340 3 1 {name=x10 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 310 -460 3 1 {name=x12 }
C {devices/lab_wire.sym} 755 -2830 0 0 {name=p134 sig_type=std_logic lab=snk_cap}
C {JNW_TR_SKY130A/JNWTR_NDX1_CV.sym} 770 -2830 0 0 {name=x76 }
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 380 -2800 0 0 {name=x77 }
C {devices/lab_wire.sym} 435 -2760 0 1 {name=p140 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 445 -2840 0 1 {name=p141 sig_type=std_logic lab=vdd}
C {JNW_ATR_SKY130A/JNWATR_PCH_2C1F2.sym} 610 -2860 0 0 {name=x78 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 520 -2800 0 0 {name=x79 }
C {JNW_TR_SKY130A/JNWTR_ORX1_CV.sym} 210 -2840 0 0 {name=x80 }
C {devices/lab_wire.sym} 250 -2890 0 1 {name=p142 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 250 -2810 0 1 {name=p143 sig_type=std_logic lab=vss

}
C {devices/lab_wire.sym} 880 -2840 0 1 {name=p144 sig_type=std_logic lab=pulseOut

}
C {devices/lab_wire.sym} 4175 -1220 0 0 {name=p55 sig_type=std_logic lab=src_gate_n}
C {devices/lab_wire.sym} 4165 -980 0 0 {name=p56 sig_type=std_logic lab=snk_gate}
C {devices/ipin.sym} 3350 -1080 0 0 {name=p57 lab=cmp}
C {devices/lab_wire.sym} 3955 -1160 0 1 {name=p58 sig_type=std_logic lab=src_gate}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 3820 -1080 0 0 {name=x19 }
C {devices/lab_wire.sym} 3875 -1120 0 1 {name=p59 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 3855 -1040 0 0 {name=p60 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 3855 -980 0 1 {name=p61 sig_type=std_logic lab=snk_gate_n}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 3540 -1160 0 0 {name=x20 }
C {devices/lab_wire.sym} 3630 -1200 0 1 {name=p62 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 3630 -1110 0 1 {name=p63 sig_type=std_logic lab=vss

}
C {devices/lab_wire.sym} 3600 -1220 0 0 {name=p64 sig_type=std_logic lab=src_n

}
C {devices/lab_wire.sym} 3830 -1290 0 1 {name=p65 sig_type=std_logic lab=vdd

}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 3550 -980 0 0 {name=x21 }
C {devices/lab_wire.sym} 3640 -1020 0 1 {name=p66 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 3640 -930 0 1 {name=p67 sig_type=std_logic lab=vss

}
C {devices/lab_wire.sym} 3610 -1040 0 0 {name=p68 sig_type=std_logic lab=snk

}
C {JNW_ATR_SKY130A/JNWATR_PCH_2C1F2.sym} 3780 -1220 0 0 {name=x22 }
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 4030 -980 0 0 {name=x36 }
C {devices/lab_wire.sym} 4070 -940 0 1 {name=p69 sig_type=std_logic lab=vss

}
C {devices/lab_wire.sym} 4070 -1020 0 1 {name=p70 sig_type=std_logic lab=vdd

}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C1F2.sym} 3730 -860 0 0 {name=x37 }
C {devices/lab_wire.sym} 3770 -830 0 1 {name=p71 sig_type=std_logic lab=vss

}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 3620 -860 0 0 {name=x38 }
C {devices/lab_wire.sym} 3660 -820 0 1 {name=p72 sig_type=std_logic lab=vss

}
C {devices/lab_wire.sym} 3660 -900 0 1 {name=p73 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 3620 -860 0 0 {name=p173 sig_type=std_logic lab=snk

}
C {devices/opin.sym} 6910 -2870 0 0 {name=p114 lab=vctrl}
C {JNW_TR_SKY130A/JNWTR_CAPX4.sym} 6610 -3285 0 0 {name=x8[30:0]}
C {devices/ipin.sym} 6810 -2660 2 0 {name=p116 lab=preChrg
}
C {devices/lab_wire.sym} 7445 -2830 0 1 {name=p117 sig_type=std_logic lab=vdd}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 6230 -2330 0 0 {name=x60 }
C {devices/lab_wire.sym} 6295 -3050 0 1 {name=p118 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 7465 -1990 0 1 {name=p119 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 7475 -2320 0 1 {name=p120 sig_type=std_logic lab=Vpre}
C {JNW_ATR_SKY130A/JNWATR_PCH_2C1F2.sym} 6230 -3050 0 0 {name=x61 }
C {JNW_ATR_SKY130A/JNWATR_NCH_2C1F2.sym} 6230 -2600 0 0 {name=x62 }
C {JNW_ATR_SKY130A/JNWATR_PCH_2C1F2.sym} 6490 -3050 0 1 {name=x63 }
C {devices/lab_wire.sym} 6505 -3000 0 0 {name=p121 sig_type=std_logic lab=vss}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C1F2.sym} 6420 -2600 0 1 {name=x64 }
C {devices/lab_wire.sym} 6335 -2600 0 0 {name=p123 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 6445 -2600 0 1 {name=p124 sig_type=std_logic lab=snk_gate_n}
C {devices/vsource.sym} 6270 -3340 0 0 {name=V_isrc1 value=0 savecurrent=true}
C {devices/vsource.sym} 6270 -2410 0 0 {name=V_isnk1 value=0 savecurrent=true}
C {JNW_ATR_SKY130A/JNWATR_PCH_2C5F0.sym} 6230 -3440 0 0 {name=x65 }
C {devices/vsource.sym} 7430 -2160 0 0 {name=V_iPreCharge2 value=0 savecurrent=true}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C1F2.sym} 7470 -2070 0 1 {name=x66 }
C {devices/lab_wire.sym} 7485 -2070 0 1 {name=p125 sig_type=std_logic lab=preChrg}
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 7430 -2300 1 0 {name=x67 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 7430 -2670 1 0 {name=x68 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 7430 -2780 1 0 {name=x69 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 7430 -2560 1 0 {name=x70 }
C {devices/vsource.sym} 6270 -2720 0 0 {name=V_isnk_drain1 value=0 savecurrent=true}
C {devices/vsource.sym} 6270 -3190 0 0 {name=V_isrc_source1 value=0 savecurrent=true}
C {devices/lab_wire.sym} 6415 -2650 0 1 {name=p126 sig_type=std_logic lab=vdd}
C {devices/vsource.sym} 6610 -3180 0 0 {name=V_icap_bot1 value=0 savecurrent=true}
C {devices/vsource.sym} 6680 -2720 0 0 {name=V_iprecharge3 value=0 savecurrent=true}
C {devices/vsource.sym} 6790 -2870 1 0 {name=V_ipmosGate1 value=0 savecurrent=true}
C {devices/vsource.sym} 6610 -3410 0 0 {name=V_icap_top1 value=0 savecurrent=true}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C1F2.sym} 6720 -2660 0 1 {name=x71 }
C {devices/lab_wire.sym} 6665 -2660 0 0 {name=p127 sig_type=std_logic lab=vss}
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 7430 -2450 1 0 {name=x72 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 7460 -2300 1 0 {name=x73 }
C {devices/ipin.sym} 5690 -3360 0 0 {name=p128 lab=snk
}
C {devices/ipin.sym} 5690 -3380 0 0 {name=p129 lab=src_n}
C {devices/vsource.sym} 6680 -2500 0 0 {name=V_iPreCharge6 value=240m savecurrent=true}
C {devices/lab_wire.sym} 6685 -2410 0 1 {name=p155 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 8160 -2330 0 0 {name=p174 sig_type=std_logic lab=pbias}
C {devices/lab_wire.sym} 7990 -2770 0 1 {name=p175 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 8080 -1930 0 1 {name=p176 sig_type=std_logic lab=vss}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 8030 -1980 0 1 {name=x28[3:0]}
C {devices/lab_wire.sym} 8200 -2450 0 0 {name=p177 sig_type=std_logic lab=vdd}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 8160 -1980 0 0 {name=x92 }
C {devices/lab_wire.sym} 8140 -1980 0 0 {name=p178 sig_type=std_logic lab=nbias}
C {devices/vsource.sym} 7990 -2080 0 0 {name=v_nbias value=0 savecurrent=true}
C {devices/vsource.sym} 8200 -2270 0 0 {name=v_pbias value=0 savecurrent=true}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 7990 -2570 1 1 {name=x93 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 7990 -2650 1 1 {name=x94 }
C {JNW_ATR_SKY130A/JNWATR_PCH_2C5F0.sym} 8160 -2390 0 0 {name=x95 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 7990 -2490 1 1 {name=x96 }
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 8030 -2230 0 1 {name=x97 }
C {devices/lab_wire.sym} 7990 -2230 0 0 {name=p179 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 6210 -3440 0 0 {name=p180 sig_type=std_logic lab=pbias}
C {devices/lab_wire.sym} 6220 -2330 0 0 {name=p181 sig_type=std_logic lab=nbias}
C {devices/lab_wire.sym} 8050 -2290 0 0 {name=p182 sig_type=std_logic lab=ncasc}
C {devices/lab_wire.sym} 6680 -2580 0 1 {name=p49 sig_type=std_logic lab=Vpre

}
C {devices/lab_wire.sym} 6215 -3050 0 0 {name=p50 sig_type=std_logic lab=src_gate_n}
C {devices/lab_wire.sym} 6205 -2600 0 0 {name=p74 sig_type=std_logic lab=snk_gate}
C {devices/ipin.sym} 5390 -2840 0 0 {name=p75 lab=cmp}
C {devices/lab_wire.sym} 5875 -3050 0 1 {name=p76 sig_type=std_logic lab=src_gate}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 6000 -3050 0 0 {name=x14 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 5580 -3050 0 0 {name=x39 }
C {devices/lab_wire.sym} 5670 -3090 0 1 {name=p77 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 5670 -3000 0 1 {name=p78 sig_type=std_logic lab=vss

}
C {devices/lab_wire.sym} 5640 -3110 0 0 {name=p79 sig_type=std_logic lab=src_n

}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 5590 -2600 0 0 {name=x40 }
C {devices/lab_wire.sym} 5680 -2640 0 1 {name=p80 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 5680 -2550 0 1 {name=p81 sig_type=std_logic lab=vss

}
C {devices/lab_wire.sym} 5650 -2660 0 0 {name=p82 sig_type=std_logic lab=snk

}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 5930 -2600 0 0 {name=x41 }
C {devices/lab_wire.sym} 5970 -2560 0 1 {name=p83 sig_type=std_logic lab=vss

}
C {devices/lab_wire.sym} 5970 -2640 0 1 {name=p84 sig_type=std_logic lab=vdd

}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C1F2.sym} 5890 -2950 0 0 {name=x42 }
C {devices/lab_wire.sym} 5930 -2920 0 1 {name=p85 sig_type=std_logic lab=vss

}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 5780 -2950 0 0 {name=x43 }
C {devices/lab_wire.sym} 5820 -2910 0 1 {name=p86 sig_type=std_logic lab=vss

}
C {devices/lab_wire.sym} 5820 -2990 0 1 {name=p87 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 5780 -2950 0 0 {name=p88 sig_type=std_logic lab=src_n

}
C {devices/lab_wire.sym} 5770 -2730 0 1 {name=p89 sig_type=std_logic lab=vdd

}
C {JNW_ATR_SKY130A/JNWATR_PCH_2C1F2.sym} 5720 -2660 0 0 {name=x44 }
C {devices/lab_wire.sym} 6505 -3050 0 1 {name=p90 sig_type=std_logic lab=src_gate}
C {devices/lab_wire.sym} 5815 -2600 0 1 {name=p91 sig_type=std_logic lab=snk_gate_n}
C {devices/lab_wire.sym} 6040 -3090 0 1 {name=p92 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 6040 -3010 0 1 {name=p93 sig_type=std_logic lab=vss

}
C {devices/opin.sym} 2820 260 0 0 {name=p131 lab=vp}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 2610 260 0 0 {name=x57 }
C {devices/lab_wire.sym} 2700 220 0 0 {name=p162 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 2680 400 2 1 {name=p163 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 2820 360 0 0 {name=x58[3:0]}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 2540 350 0 0 {name=x59[3:0]}
C {devices/ipin.sym} 2620 170 0 0 {name=p164 lab=B}
C {JNW_TR_SKY130A/JNWTR_IVX2_CV.sym} 3680 -170 0 0 {name=x85 }
C {JNW_TR_SKY130A/JNWTR_IVX2_CV.sym} 3760 -90 2 0 {name=x86 }
C {devices/lab_wire.sym} 3720 -210 0 0 {name=p165 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 3720 -130 0 0 {name=p166 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 3720 -50 2 1 {name=p171 sig_type=std_logic lab=vdd}
C {JNW_ATR_SKY130A/JNWATR_PCH_2C1F2.sym} 3590 -240 0 0 {name=x87 }
C {JNW_ATR_SKY130A/JNWATR_PCH_2C1F2.sym} 3850 -240 0 1 {name=x88 }
C {devices/lab_wire.sym} 3810 -240 0 0 {name=p172 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 3630 -240 0 1 {name=p183 sig_type=std_logic lab=vdd}
C {JNW_TR_SKY130A/JNWTR_NDX1_CV.sym} 3370 -300 0 0 {name=x89 }
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 2980 -270 0 0 {name=x90 }
C {JNW_ATR_SKY130A/JNWATR_PCH_2C1F2.sym} 3210 -330 0 0 {name=x91 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 3120 -270 0 0 {name=x98 }
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 3280 -220 0 0 {name=x99 }
C {devices/lab_wire.sym} 3310 -370 0 1 {name=p185 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 3020 -310 0 1 {name=p186 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 3020 -230 2 1 {name=p187 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 3240 -210 0 0 {name=p188 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 2960 -320 0 0 {name=p190 sig_type=std_logic lab=cmp
}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 3830 -2960 0 0 {name=x100 }
C {devices/lab_wire.sym} 3920 -2910 0 1 {name=p184 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 3920 -3000 0 1 {name=p189 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 3680 -2960 0 0 {name=p191 sig_type=std_logic lab=vref}
C {devices/lab_wire.sym} 3980 -2960 0 1 {name=p192 sig_type=std_logic lab=vin}
C {devices/lab_wire.sym} 3890 -3000 0 0 {name=p193 sig_type=std_logic lab=s_Ref2CMP}
C {devices/vsource.sym} 3760 -2960 1 0 {name=V_intoVref value=0 savecurrent=false}
C {JNW_AVV_SKY130A/OTA.sym} 3820 -2740 0 0 {name=x101}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 3970 -2880 1 0 {name=x102 }
C {devices/lab_wire.sym} 3860 -2820 0 1 {name=p194 sig_type=std_logic lab=PwrUp}
C {devices/lab_wire.sym} 3860 -2660 0 1 {name=p195 sig_type=std_logic lab=nbias}
C {devices/lab_wire.sym} 3820 -2640 2 1 {name=p196 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 3820 -2840 0 0 {name=p197 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 3920 -2790 2 1 {name=p198 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 4010 -2790 2 0 {name=p199 sig_type=std_logic lab=vdd}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 4370 -2960 0 0 {name=x45 }
C {devices/lab_wire.sym} 4460 -2910 0 1 {name=p7 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 4460 -3000 0 1 {name=p18 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 4220 -2960 0 0 {name=p44 sig_type=std_logic lab=vref}
C {devices/lab_wire.sym} 4520 -2960 0 1 {name=p94 sig_type=std_logic lab=vin}
C {devices/lab_wire.sym} 4430 -3000 0 0 {name=p95 sig_type=std_logic lab=s_Ref2CMP}
C {devices/vsource.sym} 4300 -2960 1 0 {name=V_intoVref1 value=0 savecurrent=false}
C {JNW_AVV_SKY130A/bias.sym} 2610 -3010 0 0 {name=x49}
C {devices/lab_wire.sym} 2530 -3130 0 0 {name=p107 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 2530 -3050 0 0 {name=p108 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 2690 -3130 0 1 {name=p109 sig_type=std_logic lab=pbias}
C {devices/lab_wire.sym} 2690 -3050 0 1 {name=p110 sig_type=std_logic lab=nbias}
C {JNW_AVV_SKY130A/OTA.sym} 2550 -2630 0 0 {name=x50}
C {devices/lab_wire.sym} 2590 -2550 0 1 {name=p111 sig_type=std_logic lab=nbias}
C {devices/lab_wire.sym} 2550 -2730 0 1 {name=p112 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 2590 -2710 0 1 {name=p113 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 2550 -2530 0 1 {name=p115 sig_type=std_logic lab=vss}
C {devices/opin.sym} 2760 -2630 0 0 {name=p132 lab=vn}
C {devices/lab_wire.sym} 2390 -2660 0 0 {name=p96 sig_type=std_logic lab=B}
C {JNW_AVV_SKY130A/CMP_v2.sym} 2860 -2620 0 0 {name=x53}
C {devices/lab_wire.sym} 2980 -2840 0 1 {name=p139 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 3020 -2820 0 1 {name=p145 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 2950 -2620 0 1 {name=p146 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 3010 -2660 0 1 {name=p147 sig_type=std_logic lab=nbias}
C {devices/lab_wire.sym} 3050 -2680 0 1 {name=p148 sig_type=std_logic lab=pbias}
C {devices/lab_wire.sym} 2980 -2640 0 1 {name=p149 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 3070 -2800 0 1 {name=p150 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 2870 -2770 0 0 {name=p152 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 3180 -2740 0 1 {name=p151 sig_type=std_logic lab=vp}
C {JNW_ATR_SKY130A/JNWATR_PCH_4C1F2.sym} 640 -2240 0 0 {name=x5[2:0]}
C {devices/lab_wire.sym} 820 -2360 0 1 {name=p153 sig_type=std_logic lab=vdd}
C {JNW_ATR_SKY130A/JNWATR_PCH_4C1F2.sym} 640 -2300 0 0 {name=x6[2:0]}
C {JNW_ATR_SKY130A/JNWATR_PCH_4C1F2.sym} 640 -2360 0 0 {name=x7[2:0]}
C {JNW_ATR_SKY130A/JNWATR_PCH_4C1F2.sym} 1000 -2240 0 1 {name=x9[2:0]}
C {JNW_ATR_SKY130A/JNWATR_PCH_4C1F2.sym} 1000 -2300 0 1 {name=x10[2:0]}
C {JNW_ATR_SKY130A/JNWATR_PCH_4C1F2.sym} 1000 -2360 0 1 {name=x11[2:0]}
C {devices/ipin.sym} 11050 -2350 0 0 {name=p97 lab=vdd}
C {devices/ipin.sym} 11050 -2330 0 0 {name=p98 lab=vss
}
C {devices/lab_wire.sym} 12130 -1220 0 0 {name=p99 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 11840 -2360 0 0 {name=p100 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 11840 -2450 0 1 {name=p101 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 12110 -2320 0 0 {name=p102 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 12110 -2490 0 1 {name=p103 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 12400 -2270 0 0 {name=p104 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 12650 -2270 0 1 {name=p105 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 12800 -2450 0 1 {name=p106 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 11370 -2200 0 0 {name=p122 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 11130 -2200 0 1 {name=p130 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 11590 -2200 0 0 {name=p133 sig_type=std_logic lab=vdd

}
C {JNW_TR_SKY130A/JNWTR_CAPX4.sym} 11740 -1890 0 0 {name=x14[9:0]}
C {JNW_TR_SKY130A/JNWTR_CAPX4.sym} 10980 -1890 0 1 {name=x18[9:0]}
C {sky130_fd_pr/pnp_05v5.sym} 11530 -1390 0 1 {name=Q4
model=pnp_05v5_W3p40L3p40
m=8
spiceprefix=X
}
C {sky130_fd_pr/pnp_05v5.sym} 11190 -1390 0 0 {name=Q5
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {devices/ipin.sym} 11240 -2630 0 0 {name=p135 lab=vctrl}
C {devices/lab_wire.sym} 11360 -2730 0 1 {name=p136 sig_type=std_logic lab=vdd

}
C {devices/ipin.sym} 12770 -2580 1 0 {name=p137 lab=PD}
C {devices/ipin.sym} 12380 -2240 0 0 {name=p138 lab=PB}
C {devices/ipin.sym} 12750 -2240 2 0 {name=p207 lab=PC}
C {devices/ipin.sym} 11960 -2560 1 0 {name=p208 lab=PA}
C {devices/ipin.sym} 11630 -2130 3 1 {name=p209 lab=PI2}
C {devices/ipin.sym} 10730 -2320 0 0 {name=p210 lab=dummy}
C {devices/ipin.sym} 11080 -2230 0 0 {name=p211 lab=PII1}
C {devices/ipin.sym} 11610 -2230 2 0 {name=p212 lab=PI1}
C {devices/opin.sym} 13100 -2410 0 0 {name=p213 lab=vref}
C {devices/opin.sym} 11790 -2050 0 0 {name=p214 lab=vp}
C {devices/opin.sym} 10930 -2050 2 0 {name=p215 lab=vn}
C {devices/ipin.sym} 11090 -2130 1 0 {name=p216 lab=PII2}
C {devices/lab_wire.sym} 10730 -2200 0 1 {name=p217 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 12440 -2080 0 0 {name=x12[5:0]}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 12610 -2080 0 0 {name=x13[5:0]}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 13070 -2080 0 0 {name=x15[39:0]}
C {JNW_ATR_SKY130A/JNWATR_PCH_4C5F0.sym} 11320 -2630 0 0 {name=x46 }
C {devices/vsource.sym} 11360 -2450 0 0 {name=vipmos value=0 savecurrent=true}
C {devices/vsource.sym} 11510 -1980 0 0 {name=vibigdiode value=0 savecurrent=true}
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 11510 -1590 1 0 {name=x47 }
C {devices/lab_wire.sym} 12440 -2160 0 1 {name=p218 sig_type=std_logic lab=Hcharge

}
C {devices/lab_wire.sym} 12610 -2160 0 1 {name=p219 sig_type=std_logic lab=Lcharge

}
C {devices/lab_wire.sym} 11960 -2210 0 1 {name=p220 sig_type=std_logic lab=outRes

}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 11750 -2410 0 0 {name=x48 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 12020 -2410 0 0 {name=x51 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 11510 -2290 1 0 {name=x52 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 11210 -2290 3 1 {name=x74 }
C {devices/lab_wire.sym} 12800 -2360 0 1 {name=p221 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 12510 -2270 0 1 {name=p222 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 12710 -2410 0 0 {name=x75 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 12440 -2180 3 0 {name=x81 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 12610 -2180 1 1 {name=x82 }
C {JNW_TR_SKY130A/JNWTR_NCHDL.sym} 12950 -2320 3 0 {name=x83 }
C {JNW_TR_SKY130A/JNWTR_PCHDL.sym} 12950 -2500 1 0 {name=x84 }
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 12950 -2210 3 0 {name=x103 }
C {devices/lab_wire.sym} 12950 -2170 0 1 {name=p223 sig_type=std_logic lab=PD

}
C {devices/lab_wire.sym} 12910 -2250 0 0 {name=p224 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 12950 -2460 1 1 {name=p225 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 12950 -2360 1 0 {name=p226 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 12990 -2250 0 1 {name=p227 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 10770 -2280 3 1 {name=x104 }
C {devices/lab_wire.sym} 11360 -2570 0 1 {name=p228 sig_type=std_logic lab=pmosDrain

}
C {devices/vsource.sym} 11390 -1980 0 0 {name=viCTAT1 value=0 savecurrent=true}
C {devices/lab_wire.sym} 11210 -1470 0 0 {name=p229 sig_type=std_logic lab=Vbe2

}
C {devices/vsource.sym} 11310 -1980 0 0 {name=viCTAT2 value=0 savecurrent=true}
C {devices/vsource.sym} 11210 -1980 0 0 {name=vidiode value=0 savecurrent=true}
C {devices/lab_wire.sym} 11510 -1450 0 1 {name=p230 sig_type=std_logic lab=Vbe1

}
C {devices/lab_wire.sym} 11800 -1370 0 1 {name=p231 sig_type=std_logic lab=vp

}
C {devices/ipin.sym} 11050 -2300 0 0 {name=p232 lab=preChrg}
C {devices/lab_wire.sym} 11840 -1300 0 1 {name=p233 sig_type=std_logic lab=preChrg

}
C {devices/lab_wire.sym} 12200 -1310 0 0 {name=p234 sig_type=std_logic lab=preChrg

}
C {devices/lab_wire.sym} 12370 -2410 0 0 {name=p235 sig_type=std_logic lab=topSw

}
C {devices/lab_wire.sym} 12240 -1370 3 1 {name=p236 sig_type=std_logic lab=topSw

}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 12200 -1310 0 0 {name=x105 }
C {devices/lab_wire.sym} 11270 -2050 0 1 {name=p237 sig_type=std_logic lab=vnm
}
C {devices/lab_wire.sym} 11450 -2050 0 0 {name=p238 sig_type=std_logic lab=vpm
}
C {devices/vsource.sym} 11510 -2330 0 0 {name=vipmos1 value=0 savecurrent=true}
C {devices/vsource.sym} 11210 -2350 0 0 {name=vipmos2 value=0 savecurrent=true}
C {JNW_TR_SKY130A/JNWTR_RPPO8.sym} 11390 -1530 1 0 {name=x106 }
C {JNW_TR_SKY130A/JNWTR_RPPO8.sym} 11310 -1530 3 1 {name=x107 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 11960 -2140 1 0 {name=x108 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 11960 -2020 1 0 {name=x109 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 12000 -2020 1 0 {name=x110 }
C {JNW_ATR_SKY130A/JNWATR_PCH_4C5F0.sym} 10940 -2800 0 0 {name=x111 }
C {devices/lab_wire.sym} 11000 -2860 0 1 {name=p239 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 10890 -2800 0 1 {name=p240 sig_type=std_logic lab=vctrl

}
C {JNW_ATR_SKY130A/JNWATR_NCH_4C5F0.sym} 10940 -2550 0 0 {name=x112 }
C {JNW_ATR_SKY130A/JNWATR_NCH_4C5F0.sym} 10810 -2550 0 1 {name=x16[1:0]}
C {devices/lab_wire.sym} 10830 -2700 0 1 {name=p241 sig_type=std_logic lab=pcasc

}
C {JNW_ATR_SKY130A/JNWATR_PCH_4C5F0.sym} 10810 -2700 0 1 {name=x113 }
C {JNW_ATR_SKY130A/JNWATR_PCH_4C1F2.sym} 11320 -2520 0 0 {name=x114 }
C {devices/lab_wire.sym} 11390 -2520 0 0 {name=p242 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 11270 -2520 0 1 {name=p243 sig_type=std_logic lab=pcasc

}
C {devices/vsource.sym} 10980 -2700 0 0 {name=vipmos4 value=0 savecurrent=true}
C {devices/lab_wire.sym} 10890 -2470 0 1 {name=p244 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 11550 -1590 1 0 {name=x115 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 11390 -1750 1 0 {name=x116 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 11310 -1750 3 1 {name=x117 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 11430 -1750 1 0 {name=x118 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 11270 -1670 3 0 {name=x119 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 12040 -2020 1 0 {name=x120 }
C {devices/lab_wire.sym} 10920 -1410 0 0 {name=p245 sig_type=std_logic lab=vn

}
C {devices/lab_wire.sym} 10880 -1340 0 0 {name=p246 sig_type=std_logic lab=preChrg

}
C {devices/lab_wire.sym} 11660 -2000 0 0 {name=p247 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 11660 -2090 0 1 {name=p248 sig_type=std_logic lab=vdd

}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 11570 -2050 0 0 {name=x121 }
C {devices/lab_wire.sym} 11120 -2000 0 0 {name=p249 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 11120 -2090 0 1 {name=p250 sig_type=std_logic lab=vdd

}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 11030 -2050 0 0 {name=x122 }
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 11840 -1300 0 1 {name=x123 }
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 10880 -1340 0 0 {name=x124 }
C {devices/lab_wire.sym} 11390 -2410 0 1 {name=p251 sig_type=std_logic lab=cascDrain

}
C {JNW_TR_SKY130A/JNWTR_RPPO8.sym} 9490 -1500 1 0 {name=x127 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 9490 -1380 1 0 {name=x128 }
C {JNW_TR_SKY130A/JNWTR_RPPO8.sym} 9630 -1500 1 0 {name=x143 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 9530 -1380 1 0 {name=x144 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 9570 -1380 1 0 {name=x145 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 9630 -1380 1 0 {name=x146 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 9670 -1380 1 0 {name=x147 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 9710 -1380 1 0 {name=x148 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1830 -1980 0 0 {name=x149 }
C {devices/lab_wire.sym} 1920 -1930 0 1 {name=p252 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 1920 -2020 0 1 {name=p253 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 1980 -1980 0 1 {name=p254 sig_type=std_logic lab=vin}
C {devices/lab_wire.sym} 1880 -2130 0 0 {name=p255 sig_type=std_logic lab=s_Ref2CMP}
C {devices/vsource.sym} 1760 -1980 1 0 {name=V_intoVref2 value=0 savecurrent=false}
C {JNW_AVV_SKY130A/OTA.sym} 1820 -1760 0 0 {name=x150}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1970 -1900 1 0 {name=x151 }
C {devices/lab_wire.sym} 1860 -1840 0 1 {name=p256 sig_type=std_logic lab=PwrUp}
C {devices/lab_wire.sym} 1860 -1680 0 1 {name=p257 sig_type=std_logic lab=nbias}
C {devices/lab_wire.sym} 1820 -1660 2 1 {name=p258 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 1820 -1860 0 0 {name=p259 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 1920 -1810 2 1 {name=p260 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 2010 -1810 2 0 {name=p261 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 2010 -1840 0 1 {name=p262 sig_type=std_logic lab=s_CmpOutDisable}
C {JNW_TR_SKY130A/JNWTR_ANX1_CV.sym} 1880 -2130 1 0 {name=x152 }
C {devices/lab_wire.sym} 1900 -2210 0 1 {name=p263 sig_type=std_logic lab=s_CmpOutDisable}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 1900 -2210 3 1 {name=x153 }
C {devices/lab_wire.sym} 1940 -2170 1 0 {name=p264 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 1860 -2170 1 0 {name=p265 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 1850 -2090 1 0 {name=p266 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 1930 -2090 1 0 {name=p267 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 1970 -1670 0 1 {name=p268 sig_type=std_logic lab=OTAout}
C {devices/lab_wire.sym} 1590 -1970 0 0 {name=p269 sig_type=std_logic lab=vref}
C {devices/vcvs.sym} 1630 -1950 0 0 {name=E1 value=10000}
C {devices/lab_wire.sym} 1630 -1920 2 1 {name=p270 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 1660 -1980 0 1 {name=p271 sig_type=std_logic lab=OTAvip}
C {devices/lab_wire.sym} 1590 -1930 0 0 {name=p272 sig_type=std_logic lab=OTAvip}
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 9000 -910 1 0 {name=x125 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 9040 -910 1 0 {name=x126 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 9080 -910 1 0 {name=x129 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 9120 -910 1 0 {name=x130 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 8880 -990 1 0 {name=x131 }
C {JNW_TR_SKY130A/JNWTR_RPPO8.sym} 8920 -1070 1 0 {name=x132 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 8620 -1070 3 1 {name=x133 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 8790 -990 1 0 {name=x134 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 8710 -990 3 1 {name=x135 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 8620 -990 3 1 {name=x136 }
C {JNW_TR_SKY130A/JNWTR_RPPO8.sym} 8830 -1070 1 0 {name=x137 }
C {JNW_TR_SKY130A/JNWTR_RPPO8.sym} 8670 -1070 3 1 {name=x138 }
C {JNW_TR_SKY130A/JNWTR_RPPO8.sym} 8580 -1070 3 1 {name=x139 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 8710 -1070 3 1 {name=x140 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 8790 -1070 1 0 {name=x141 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 8880 -1070 1 0 {name=x142 }
C {devices/lab_wire.sym} 7110 -620 0 1 {name=p154 sig_type=std_logic lab=in_intermediate}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C1F2.sym} 6820 -620 0 0 {name=x54}
C {devices/lab_wire.sym} 7030 -620 0 1 {name=p156 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 6860 -620 0 1 {name=p157 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 6940 -680 0 1 {name=p158 sig_type=std_logic lab=vdd}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 6900 -420 0 1 {name=x55 }
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 6990 -420 0 0 {name=x56 }
C {devices/lab_wire.sym} 6940 -360 0 1 {name=p159 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 6930 -420 0 1 {name=p160 sig_type=std_logic lab=nbias}
C {devices/lab_wire.sym} 6800 -550 0 0 {name=p161 sig_type=std_logic lab=ipShifted}
C {devices/lab_wire.sym} 7060 -550 0 1 {name=p167 sig_type=std_logic lab=inShifted}
C {devices/vsource.sym} 6860 -500 0 0 {name=v_lvlShft value=0 savecurrent=true}
C {devices/vsource.sym} 7030 -500 0 0 {name=v_lvlShft1 value=0 savecurrent=true}
C {JNW_ATR_SKY130A/JNWATR_PCH_2C5F0.sym} 6510 -620 0 1 {name=x17[7:0]}
C {JNW_ATR_SKY130A/JNWATR_PCH_2C5F0.sym} 6580 -620 0 0 {name=x19[7:0]}
C {devices/lab_wire.sym} 6620 -520 0 1 {name=p168 sig_type=std_logic lab=vdd}
C {JNW_ATR_SKY130A/JNWATR_PCH_4C1F2.sym} 6580 -520 0 0 {name=x58}
C {JNW_ATR_SKY130A/JNWATR_PCH_4C1F2.sym} 6430 -520 0 0 {name=x59}
C {devices/lab_wire.sym} 6540 -690 0 1 {name=p169 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 6470 -520 0 1 {name=p170 sig_type=std_logic lab=vdd}
C {devices/lab_wire.sym} 6400 -520 0 0 {name=p200 sig_type=std_logic lab=ip}
C {devices/lab_wire.sym} 6540 -520 0 1 {name=p201 sig_type=std_logic lab=in}
C {devices/lab_wire.sym} 6800 -620 0 0 {name=p202 sig_type=std_logic lab=ip_intermediate}
C {devices/lab_wire.sym} 6470 -570 0 0 {name=p203 sig_type=std_logic lab=ip_intermediate}
C {devices/lab_wire.sym} 6620 -570 0 1 {name=p204 sig_type=std_logic lab=in_intermediate}
C {devices/lab_wire.sym} 6560 -620 0 0 {name=p205 sig_type=std_logic lab=pbias}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C1F2.sym} 7070 -620 0 1 {name=x154}
