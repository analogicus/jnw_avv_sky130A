v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 1580 -1280 1580 -1010 {
lab=outRes}
N 1460 -1230 1460 -1190 {
lab=vss}
N 1460 -1360 1460 -1320 {
lab=vdd}
N 1430 -1400 1430 -1320 {
lab=PA}
N 1730 -1230 1730 -1190 {
lab=vss}
N 1730 -1360 1730 -1320 {
lab=vdd}
N 1700 -1400 1700 -1320 {
lab=PA}
N 2000 -1110 2020 -1110 {
lab=PB}
N 2270 -1110 2370 -1110 {
lab=PC}
N 2390 -1390 2390 -1320 {
lab=PD}
N 2690 -1280 2690 -1010 {
lab=vref}
N 340 -1070 380 -1070 {
lab=vdd}
N 470 -1070 920 -1070 {
lab=vss}
N 960 -920 960 -910 {
lab=vpm}
N 970 -930 980 -930 {
lab=vpm}
N 430 -920 430 -910 {
lab=vnm}
N 420 -930 430 -930 {
lab=vnm}
N 980 -920 980 -910 {
lab=vpm}
N 1200 -920 1250 -920 {
lab=vp}
N 1200 -920 1200 -820 {
lab=vp}
N 430 -930 430 -920 {
lab=vnm}
N 960 -930 960 -920 {
lab=vpm}
N 420 -910 430 -910 {
lab=vnm}
N 430 -920 640 -920 {
lab=vnm}
N 140 -920 190 -920 {
lab=vn}
N 190 -920 190 -820 {
lab=vn}
N 410 -920 410 -910 {
lab=vnm}
N 190 -750 190 -220 {
lab=vss}
N 2230 -220 2690 -220 {
lab=vss}
N 2690 -940 2690 -220 {
lab=vss}
N 2230 -940 2230 -220 {
lab=vss}
N 2060 -220 2230 -220 {
lab=vss}
N 2060 -940 2060 -220 {
lab=vss}
N 1200 -750 1200 -220 {
lab=vss}
N 970 -220 1200 -220 {
lab=vss}
N 1860 -220 2060 -220 {
lab=vss}
N 970 -340 970 -220 {
lab=vss}
N 420 -340 420 -220 {
lab=vss}
N 190 -220 420 -220 {
lab=vss}
N 380 -390 380 -340 {
lab=vss}
N 380 -340 420 -340 {
lab=vss}
N 1010 -390 1010 -340 {
lab=vss}
N 970 -340 1010 -340 {
lab=vss}
N 970 -360 970 -340 {
lab=vss}
N 1120 -870 1120 -830 {
lab=vss}
N 330 -870 330 -830 {
lab=vss}
N 1120 -1000 1120 -960 {
lab=vdd}
N 330 -1000 330 -960 {
lab=vdd}
N 640 -1560 690 -1560 {
lab=vctrl}
N 730 -1660 730 -1560 {
lab=vdd}
N 300 -990 300 -960 {
lab=PII2}
N 230 -990 300 -990 {
lab=PII2}
N 1060 -990 1090 -990 {
lab=PI2}
N 2690 -1280 2720 -1280 {
lab=vref}
N 1580 -1400 1700 -1400 {
lab=PA}
N 1580 -1430 1580 -1400 {
lab=PA}
N 1430 -1400 1580 -1400 {
lab=PA}
N 290 -1100 380 -1100 {
lab=PII1}
N 1470 -1730 1510 -1730 {
lab=dummy}
N 1510 -1730 1510 -1690 {
lab=dummy}
N 1530 -1650 1530 -1610 {
lab=vss}
N 1470 -1610 1530 -1610 {
lab=vss}
N 420 -360 420 -340 {
lab=vss}
N 800 -920 960 -920 {
lab=vpm}
N 970 -910 980 -910 {
lab=vpm}
N 730 -1320 730 -1280 {
lab=cascDrain}
N 420 -1280 730 -1280 {
lab=cascDrain}
N 970 -910 970 -880 {
lab=vpm}
N 960 -910 970 -910 {
lab=vpm}
N 1580 -1280 1650 -1280 {
lab=outRes}
N 970 -1280 1380 -1280 {
lab=cascDrain}
N 970 -1050 970 -930 {
lab=vpm}
N 960 -930 970 -930 {
lab=vpm}
N 980 -920 1040 -920 {
lab=vpm}
N 980 -930 980 -920 {
lab=vpm}
N 350 -920 410 -920 {
lab=vnm}
N 410 -930 410 -920 {
lab=vnm}
N 420 -1050 420 -930 {
lab=vnm}
N 410 -930 420 -930 {
lab=vnm}
N 190 -920 250 -920 {
lab=vn}
N 1140 -920 1200 -920 {
lab=vp}
N 1090 -990 1090 -960 {
lab=PI2}
N 2060 -1280 2060 -1160 {
lab=topSw}
N 2060 -1060 2060 -1010 {
lab=Hcharge}
N 2230 -1280 2230 -1160 {
lab=topSw}
N 2060 -1280 2230 -1280 {
lab=topSw}
N 2230 -1060 2230 -1010 {
lab=Lcharge}
N 2110 -1140 2180 -1140 {
lab=vss}
N 2570 -1390 2570 -1370 {
lab=PD}
N 2390 -1390 2570 -1390 {
lab=PD}
N 2390 -1450 2390 -1390 {
lab=PD}
N 2570 -1080 2570 -1040 {
lab=PD}
N 2570 -1190 2570 -1160 {
lab=#net1}
N 2230 -1280 2360 -1280 {
lab=topSw}
N 640 -920 640 -880 {
lab=vnm}
N 800 -920 800 -880 {
lab=vpm}
N 420 -910 420 -880 {
lab=vnm}
N 410 -910 420 -910 {
lab=vnm}
N 420 -820 420 -420 {
lab=Vbe2}
N 1750 -1280 2060 -1280 {
lab=topSw}
N 1480 -1280 1580 -1280 {
lab=outRes}
N 1280 -400 1280 -340 {
lab=vp}
N 1200 -220 1280 -220 {
lab=vss}
N 130 -400 130 -340 {
lab=vn}
N 130 -220 190 -220 {
lab=vss}
N 130 -310 130 -220 {
lab=vss}
N 1280 -310 1280 -220 {
lab=vss}
N 1860 -400 1860 -340 {
lab=topSw}
N 1860 -310 1860 -220 {
lab=vss}
N 970 -1170 970 -1150 {lab=#net2}
N 970 -1280 970 -1230 {lab=cascDrain}
N 730 -1280 970 -1280 {
lab=cascDrain}
N 420 -1280 420 -1250 {lab=cascDrain}
N 420 -1190 420 -1150 {lab=#net3}
N 1280 -220 1560 -220 {
lab=vss}
N 1560 -970 1560 -220 {lab=vss}
N 1580 -220 1860 -220 {
lab=vss}
N 1190 -1750 1190 -1690 {lab=vdd}
N 1190 -1750 1230 -1750 {lab=vdd}
N 1190 -1500 1190 -1470 {lab=#net4}
N 1190 -1440 1190 -1330 {lab=vss}
N 1130 -1440 1150 -1440 {lab=#net4}
N 980 -1440 980 -1330 {lab=vss}
N 980 -1540 980 -1470 {lab=pcasc}
N 1040 -1750 1190 -1750 {lab=vdd}
N 1040 -1590 1070 -1590 {lab=pcasc}
N 1130 -1500 1190 -1500 {lab=#net4}
N 1190 -1560 1190 -1500 {lab=#net4}
N 1130 -1500 1130 -1440 {lab=#net4}
N 1090 -1440 1130 -1440 {lab=#net4}
N 1040 -1590 1040 -1540 {lab=pcasc}
N 980 -1540 1040 -1540 {lab=pcasc}
N 1020 -1590 1040 -1590 {lab=pcasc}
N 980 -1560 980 -1540 {lab=pcasc}
N 730 -1430 760 -1430 {lab=vdd}
N 640 -1430 690 -1430 {lab=pcasc}
N 1190 -1660 1190 -1620 {lab=#net5}
N 1090 -1330 1190 -1330 {lab=vss}
N 2600 -1280 2690 -1280 {
lab=vref}
N 1100 -1690 1150 -1690 {lab=vctrl}
N 350 -1280 420 -1280 {lab=cascDrain}
N 140 -1280 250 -1280 {lab=Iptat}
N 950 -220 970 -220 {
lab=vss}
N 640 -220 690 -220 {
lab=vss}
N 690 -260 690 -220 {lab=vss}
N 800 -220 950 -220 {
lab=vss}
N 750 -260 750 -220 {lab=vss}
N 1010 -1100 1070 -1100 {lab=PI1}
N 1010 -1070 1050 -1070 {lab=vdd}
N 720 -220 750 -220 {
lab=vss}
N 270 -1480 310 -1480 {lab=PwrUp}
N 390 -1480 450 -1480 {lab=PwrUp_N}
N 1090 -1380 1090 -1330 {lab=vss}
N 980 -1330 1090 -1330 {lab=vss}
N 1090 -1440 1090 -1410 {lab=#net4}
N 1020 -1440 1090 -1440 {lab=#net4}
N 980 -1750 980 -1590 {lab=vdd}
N 1040 -1750 1040 -1650 {lab=vdd}
N 980 -1750 1040 -1750 {lab=vdd}
N 1040 -1620 1040 -1590 {lab=pcasc}
N 1560 -220 1580 -220 {
lab=vss}
N 1580 -930 1580 -220 {lab=vss}
N 2540 -1330 2540 -1280 {lab=vref}
N 2440 -1280 2540 -1280 {
lab=vref}
N 2540 -1280 2540 -1230 {lab=vref}
N 2600 -1280 2600 -1230 {lab=vref}
N 2600 -1330 2600 -1280 {lab=vref}
N 2540 -1280 2600 -1280 {
lab=vref}
N 1560 -970 1600 -970 {lab=vss}
N 1580 -1010 1620 -1010 {lab=outRes}
N 1580 -930 1620 -930 {lab=vss}
N 970 -510 970 -420 {
lab=Vbe1}
N 970 -820 970 -590 {
lab=#net6}
N 950 -550 950 -220 {
lab=vss}
N 950 -550 1070 -550 {lab=vss}
N 970 -590 1090 -590 {lab=#net6}
N 970 -510 1090 -510 {lab=Vbe1}
N 720 -490 810 -490 {lab=vss}
N 640 -820 640 -750 {lab=#net7}
N 800 -820 800 -750 {lab=#net8}
N 800 -750 840 -750 {lab=#net8}
N 800 -670 840 -670 {lab=#net9}
N 600 -670 640 -670 {lab=#net10}
N 600 -750 640 -750 {lab=#net7}
N 720 -490 720 -220 {lab=vss}
N 620 -710 720 -710 {lab=vss}
N 720 -710 720 -490 {lab=vss}
N 640 -670 640 -530 {lab=#net10}
N 800 -670 800 -530 {lab=#net9}
N 720 -710 820 -710 {lab=vss}
N 800 -530 830 -530 {lab=#net9}
N 610 -530 640 -530 {lab=#net10}
N 630 -490 720 -490 {lab=vss}
N 690 -220 720 -220 {
lab=vss}
N 610 -450 640 -450 {lab=#net11}
N 800 -450 830 -450 {lab=#net12}
N 800 -450 800 -340 {lab=#net12}
N 640 -450 640 -340 {lab=#net11}
N 640 -240 640 -220 {lab=vss}
N 420 -220 640 -220 {
lab=vss}
N 800 -240 800 -220 {lab=vss}
N 750 -220 800 -220 {
lab=vss}
N 730 -1400 730 -1380 {lab=#net13}
N 730 -1530 730 -1460 {lab=pmosDrain}
C {devices/ipin.sym} 470 -1710 0 0 {name=p1 lab=vdd}
C {devices/ipin.sym} 470 -1590 0 0 {name=p2 lab=vss
}
C {devices/lab_wire.sym} 1750 -220 0 0 {name=p4 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 1460 -1190 0 0 {name=p5 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 1460 -1360 0 1 {name=p6 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 1730 -1190 0 0 {name=p9 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 1730 -1360 0 1 {name=p11 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 2020 -1140 0 0 {name=p12 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 2270 -1140 0 1 {name=p13 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 2420 -1320 0 1 {name=p17 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 740 -1070 0 0 {name=p18 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 340 -1070 0 1 {name=p19 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 1050 -1070 0 0 {name=p20 sig_type=std_logic lab=vdd

}
C {JNW_TR_SKY130A/JNWTR_CAPX4.sym} 1200 -760 0 0 {name=x14[9:0]}
C {JNW_TR_SKY130A/JNWTR_CAPX4.sym} 190 -760 0 1 {name=x18[9:0]}
C {sky130_fd_pr/pnp_05v5.sym} 990 -390 0 1 {name=Q1
model=pnp_05v5_W3p40L3p40
m=8
spiceprefix=X
}
C {sky130_fd_pr/pnp_05v5.sym} 400 -390 0 0 {name=Q2
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {devices/lab_wire.sym} 1120 -830 0 1 {name=p23 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 330 -830 0 1 {name=p24 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 1120 -1000 0 0 {name=p25 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 330 -1000 0 0 {name=p26 sig_type=std_logic lab=vdd

}
C {devices/ipin.sym} 470 -1690 0 0 {name=p27 lab=vctrl}
C {devices/lab_wire.sym} 730 -1660 0 1 {name=p28 sig_type=std_logic lab=vdd

}
C {devices/ipin.sym} 2390 -1450 1 0 {name=p8 lab=PD}
C {devices/ipin.sym} 2000 -1110 0 0 {name=p10 lab=PB}
C {devices/ipin.sym} 2370 -1110 2 0 {name=p15 lab=PC}
C {devices/ipin.sym} 1580 -1430 1 0 {name=p16 lab=PA}
C {devices/ipin.sym} 1060 -990 2 1 {name=p31 lab=PI2}
C {devices/ipin.sym} 1470 -1730 0 0 {name=p32 lab=dummy}
C {devices/ipin.sym} 290 -1100 0 0 {name=p33 lab=PII1}
C {devices/ipin.sym} 1070 -1100 2 0 {name=p34 lab=PI1}
C {devices/opin.sym} 2720 -1280 0 0 {name=p3 lab=vref}
C {devices/opin.sym} 1250 -920 0 0 {name=p21 lab=vp}
C {devices/opin.sym} 140 -920 2 0 {name=p22 lab=vn}
C {devices/ipin.sym} 230 -990 0 0 {name=p29 lab=PII2}
C {devices/lab_wire.sym} 1470 -1610 0 1 {name=p30 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 2060 -950 0 0 {name=x1[5:0]}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 2230 -950 0 0 {name=x2[5:0]}
C {JNW_TR_SKY130A/JNWTR_CAPX4.sym} 2690 -950 0 0 {name=x3[9:0]}
C {JNW_ATR_SKY130A/JNWATR_PCH_4C5F0.sym} 690 -1560 0 0 {name=x9 }
C {devices/vsource.sym} 730 -1350 0 0 {name=vipmos value=0 savecurrent=true}
C {devices/vsource.sym} 970 -850 0 0 {name=vibigdiode value=0 savecurrent=true}
C {devices/lab_wire.sym} 2060 -1030 0 1 {name=p35 sig_type=std_logic lab=Hcharge

}
C {devices/lab_wire.sym} 2230 -1030 0 1 {name=p36 sig_type=std_logic lab=Lcharge

}
C {devices/lab_wire.sym} 1580 -1210 0 1 {name=p37 sig_type=std_logic lab=outRes

}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1370 -1280 0 0 {name=x1 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1640 -1280 0 0 {name=x3 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 970 -1160 1 0 {name=x6 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 420 -1160 3 1 {name=x7 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 240 -920 0 0 {name=x11 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1030 -920 0 0 {name=x12 }
C {devices/lab_wire.sym} 2420 -1230 0 1 {name=p42 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 2130 -1140 0 1 {name=p38 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 2330 -1280 0 0 {name=x5 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 2060 -1050 3 0 {name=x13 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 2230 -1050 1 1 {name=x17 }
C {JNW_TR_SKY130A/JNWTR_NCHDL.sym} 2570 -1190 3 0 {name=x23 }
C {JNW_TR_SKY130A/JNWTR_PCHDL.sym} 2570 -1370 1 0 {name=x24 }
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 2570 -1080 3 0 {name=x25 }
C {devices/lab_wire.sym} 2570 -1040 0 1 {name=p7 sig_type=std_logic lab=PD

}
C {devices/lab_wire.sym} 2530 -1120 0 0 {name=p14 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 2570 -1330 1 1 {name=p39 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 2570 -1230 1 0 {name=p40 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 2610 -1120 0 1 {name=p41 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 1510 -1690 3 1 {name=x15 }
C {devices/lab_wire.sym} 730 -1500 0 1 {name=p43 sig_type=std_logic lab=pmosDrain

}
C {devices/vsource.sym} 800 -850 0 0 {name=viCTAT1 value=0 savecurrent=true}
C {devices/lab_wire.sym} 420 -470 0 0 {name=p44 sig_type=std_logic lab=Vbe2

}
C {devices/vsource.sym} 640 -850 0 0 {name=viCTAT2 value=0 savecurrent=true}
C {devices/vsource.sym} 420 -850 0 0 {name=vidiode value=0 savecurrent=true}
C {devices/lab_wire.sym} 970 -450 0 1 {name=p45 sig_type=std_logic lab=Vbe1

}
C {devices/lab_wire.sym} 130 -400 0 1 {name=p55 sig_type=std_logic lab=vn

}
C {devices/lab_wire.sym} 1280 -400 0 1 {name=p56 sig_type=std_logic lab=vp

}
C {devices/ipin.sym} 470 -1670 0 0 {name=p57 lab=preChrg}
C {devices/lab_wire.sym} 90 -310 0 0 {name=p51 sig_type=std_logic lab=preChrg

}
C {devices/lab_wire.sym} 1320 -310 0 1 {name=p54 sig_type=std_logic lab=preChrg

}
C {devices/lab_wire.sym} 1820 -310 0 0 {name=p47 sig_type=std_logic lab=preChrg

}
C {devices/lab_wire.sym} 1990 -1280 0 0 {name=p46 sig_type=std_logic lab=topSw

}
C {devices/lab_wire.sym} 1860 -400 3 1 {name=p48 sig_type=std_logic lab=topSw

}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 1820 -310 0 0 {name=x29 }
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 90 -310 0 0 {name=x26 }
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 1320 -310 0 1 {name=x27 }
C {devices/lab_wire.sym} 480 -920 0 1 {name=p49 sig_type=std_logic lab=vnm
}
C {devices/lab_wire.sym} 860 -920 0 0 {name=p50 sig_type=std_logic lab=vpm
}
C {devices/vsource.sym} 970 -1200 0 0 {name=vipmos1 value=0 savecurrent=true}
C {devices/vsource.sym} 420 -1220 0 0 {name=vipmos2 value=0 savecurrent=true}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 1580 -1010 1 0 {name=x4 }
C {JNW_ATR_SKY130A/JNWATR_PCH_4C5F0.sym} 1150 -1690 0 0 {name=x56 }
C {devices/lab_wire.sym} 1210 -1750 0 1 {name=p123 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 1140 -1690 0 0 {name=p124 sig_type=std_logic lab=vctrl

}
C {JNW_ATR_SKY130A/JNWATR_NCH_4C5F0.sym} 1150 -1440 0 0 {name=x57 }
C {JNW_ATR_SKY130A/JNWATR_NCH_4C5F0.sym} 1020 -1440 0 1 {name=x58[1:0]}
C {devices/lab_wire.sym} 1040 -1590 0 1 {name=p125 sig_type=std_logic lab=pcasc

}
C {JNW_ATR_SKY130A/JNWATR_PCH_4C5F0.sym} 1020 -1590 0 1 {name=x59 }
C {JNW_ATR_SKY130A/JNWATR_PCH_4C1F2.sym} 690 -1430 0 0 {name=x60 }
C {devices/lab_wire.sym} 760 -1430 0 0 {name=p126 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 640 -1430 0 1 {name=p127 sig_type=std_logic lab=pcasc

}
C {devices/vsource.sym} 1190 -1590 0 0 {name=vipmos4 value=0 savecurrent=true}
C {devices/lab_wire.sym} 1100 -1330 0 1 {name=p128 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 670 -1560 0 0 {name=p52 sig_type=std_logic lab=vctrl

}
C {devices/lab_wire.sym} 730 -1280 0 1 {name=p61 sig_type=std_logic lab=cascDrain

}
C {devices/ipin.sym} 470 -1650 0 0 {name=p62 lab=s_Rdiscon_N}
C {devices/ipin.sym} 470 -1630 0 0 {name=p65 lab=s_PtatOut}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 360 -1280 0 1 {name=x32 }
C {devices/lab_wire.sym} 270 -1320 0 0 {name=p53 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 270 -1230 0 0 {name=p58 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 300 -1320 0 1 {name=p59 sig_type=std_logic lab=s_PtatOut

}
C {devices/opin.sym} 140 -1280 2 0 {name=p60 lab=Iptat}
C {devices/lab_wire.sym} 840 -290 0 1 {name=p63 sig_type=std_logic lab=s_Rdiscon_N

}
C {devices/lab_wire.sym} 600 -290 0 0 {name=p64 sig_type=std_logic lab=s_Rdiscon_N

}
C {devices/ipin.sym} 470 -1610 0 0 {name=p68 lab=PwrUp
}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 310 -1480 0 0 {name=x16 }
C {devices/lab_wire.sym} 290 -1480 0 0 {name=p69 sig_type=std_logic lab=PwrUp}
C {devices/lab_wire.sym} 450 -1480 0 0 {name=p70 sig_type=std_logic lab=PwrUp_N}
C {devices/lab_wire.sym} 350 -1440 0 0 {name=p71 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 350 -1520 0 0 {name=p72 sig_type=std_logic lab=vdd}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C1F2.sym} 1050 -1380 0 0 {name=x20 }
C {devices/lab_wire.sym} 1050 -1380 0 0 {name=p73 sig_type=std_logic lab=PwrUp_N}
C {JNW_ATR_SKY130A/JNWATR_PCH_2C1F2.sym} 1080 -1650 0 1 {name=x33 }
C {devices/lab_wire.sym} 1080 -1650 0 1 {name=p75 sig_type=std_logic lab=PwrUp}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 800 -530 1 0 {name=x206 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 1090 -590 1 0 {name=x207 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 1050 -590 1 0 {name=x208 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 1010 -590 1 0 {name=x209 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 970 -590 1 0 {name=x210 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 830 -530 1 0 {name=x211 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 640 -530 3 1 {name=x212 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 610 -530 3 1 {name=x213 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 800 -750 1 0 {name=x214 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 640 -750 3 1 {name=x215 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 600 -750 3 1 {name=x216 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 840 -750 1 0 {name=x217 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 1620 -1010 1 0 {name=x2 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 800 -350 1 0 {name=x8 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 640 -350 3 1 {name=x10 }
C {devices/lab_wire.sym} 600 -260 0 0 {name=p66 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 840 -260 0 1 {name=p67 sig_type=std_logic lab=vdd

}
