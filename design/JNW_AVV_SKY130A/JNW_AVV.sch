v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 1390 -1540 1390 -1270 {
lab=outRes}
N 1270 -1490 1270 -1450 {
lab=vss}
N 1270 -1620 1270 -1580 {
lab=vdd}
N 1240 -1660 1240 -1580 {
lab=PA}
N 1540 -1490 1540 -1450 {
lab=vss}
N 1540 -1620 1540 -1580 {
lab=vdd}
N 1510 -1660 1510 -1580 {
lab=PA}
N 1810 -1370 1830 -1370 {
lab=PB}
N 2080 -1370 2180 -1370 {
lab=PC}
N 2200 -1650 2200 -1580 {
lab=PD}
N 2500 -1540 2500 -1270 {
lab=vref}
N 150 -1330 190 -1330 {
lab=vdd}
N 280 -1330 730 -1330 {
lab=vss}
N 770 -1180 770 -1170 {
lab=vpm}
N 780 -1190 790 -1190 {
lab=vpm}
N 240 -1180 240 -1170 {
lab=vnm}
N 230 -1190 240 -1190 {
lab=vnm}
N 790 -1180 790 -1170 {
lab=vpm}
N 1010 -1180 1060 -1180 {
lab=vp}
N 1010 -1180 1010 -1080 {
lab=vp}
N 240 -1190 240 -1180 {
lab=vnm}
N 770 -1190 770 -1180 {
lab=vpm}
N 230 -1170 240 -1170 {
lab=vnm}
N 240 -1180 450 -1180 {
lab=vnm}
N -50 -1180 0 -1180 {
lab=vn}
N 0 -1180 0 -1080 {
lab=vn}
N 220 -1180 220 -1170 {
lab=vnm}
N 0 -1010 0 -350 {
lab=vss}
N 2040 -350 2500 -350 {
lab=vss}
N 2500 -1200 2500 -350 {
lab=vss}
N 2040 -1200 2040 -350 {
lab=vss}
N 1870 -350 2040 -350 {
lab=vss}
N 1870 -1200 1870 -350 {
lab=vss}
N 1010 -1010 1010 -350 {
lab=vss}
N 780 -350 1010 -350 {
lab=vss}
N 1670 -350 1870 -350 {
lab=vss}
N 780 -470 780 -350 {
lab=vss}
N 230 -470 230 -350 {
lab=vss}
N 0 -350 230 -350 {
lab=vss}
N 190 -520 190 -470 {
lab=vss}
N 190 -470 230 -470 {
lab=vss}
N 820 -520 820 -470 {
lab=vss}
N 780 -470 820 -470 {
lab=vss}
N 780 -490 780 -470 {
lab=vss}
N 930 -1130 930 -1090 {
lab=vss}
N 140 -1130 140 -1090 {
lab=vss}
N 930 -1260 930 -1220 {
lab=vdd}
N 140 -1260 140 -1220 {
lab=vdd}
N 450 -1820 500 -1820 {
lab=vctrl}
N 540 -1920 540 -1820 {
lab=vdd}
N 110 -1250 110 -1220 {
lab=PII2}
N 40 -1250 110 -1250 {
lab=PII2}
N 870 -1250 900 -1250 {
lab=PI2}
N 2500 -1540 2530 -1540 {
lab=vref}
N 1390 -1660 1510 -1660 {
lab=PA}
N 1390 -1690 1390 -1660 {
lab=PA}
N 1240 -1660 1390 -1660 {
lab=PA}
N 100 -1360 190 -1360 {
lab=PII1}
N 1280 -1990 1320 -1990 {
lab=dummy}
N 1320 -1990 1320 -1950 {
lab=dummy}
N 1340 -1910 1340 -1870 {
lab=vss}
N 1280 -1870 1340 -1870 {
lab=vss}
N 230 -490 230 -470 {
lab=vss}
N 610 -1180 770 -1180 {
lab=vpm}
N 780 -1170 790 -1170 {
lab=vpm}
N 540 -1790 540 -1640 {
lab=pmosDrain}
N 540 -1580 540 -1540 {
lab=cascDrain}
N 230 -1540 540 -1540 {
lab=cascDrain}
N 780 -1170 780 -1140 {
lab=vpm}
N 770 -1170 780 -1170 {
lab=vpm}
N 1390 -1540 1460 -1540 {
lab=outRes}
N 780 -1540 1190 -1540 {
lab=cascDrain}
N 780 -1310 780 -1190 {
lab=vpm}
N 770 -1190 780 -1190 {
lab=vpm}
N 790 -1180 850 -1180 {
lab=vpm}
N 790 -1190 790 -1180 {
lab=vpm}
N 160 -1180 220 -1180 {
lab=vnm}
N 220 -1190 220 -1180 {
lab=vnm}
N 230 -1310 230 -1190 {
lab=vnm}
N 220 -1190 230 -1190 {
lab=vnm}
N 0 -1180 60 -1180 {
lab=vn}
N 950 -1180 1010 -1180 {
lab=vp}
N 900 -1250 900 -1220 {
lab=PI2}
N 1870 -1540 1870 -1420 {
lab=topSw}
N 1870 -1320 1870 -1270 {
lab=Hcharge}
N 2040 -1540 2040 -1420 {
lab=topSw}
N 1870 -1540 2040 -1540 {
lab=topSw}
N 2040 -1320 2040 -1270 {
lab=Lcharge}
N 1920 -1400 1990 -1400 {
lab=vss}
N 2380 -1650 2380 -1630 {
lab=PD}
N 2200 -1650 2380 -1650 {
lab=PD}
N 2200 -1710 2200 -1650 {
lab=PD}
N 2380 -1340 2380 -1300 {
lab=PD}
N 2380 -1450 2380 -1420 {
lab=#net1}
N 2040 -1540 2170 -1540 {
lab=topSw}
N 450 -1180 450 -1140 {
lab=vnm}
N 610 -1180 610 -1140 {
lab=vpm}
N 230 -1170 230 -1140 {
lab=vnm}
N 220 -1170 230 -1170 {
lab=vnm}
N 230 -1080 230 -550 {
lab=Vbe2}
N 1560 -1540 1870 -1540 {
lab=topSw}
N 1290 -1540 1390 -1540 {
lab=outRes}
N 1090 -530 1090 -470 {
lab=vp}
N 1010 -350 1090 -350 {
lab=vss}
N -60 -530 -60 -470 {
lab=vn}
N -60 -350 0 -350 {
lab=vss}
N -60 -440 -60 -350 {
lab=vss}
N 1090 -440 1090 -350 {
lab=vss}
N 1670 -530 1670 -470 {
lab=topSw}
N 1670 -440 1670 -350 {
lab=vss}
N 780 -1430 780 -1410 {lab=#net2}
N 780 -1540 780 -1490 {lab=cascDrain}
N 540 -1540 780 -1540 {
lab=cascDrain}
N 230 -1540 230 -1510 {lab=cascDrain}
N 230 -1450 230 -1410 {lab=#net3}
N 1090 -350 1370 -350 {
lab=vss}
N 1370 -1230 1370 -350 {lab=vss}
N 1390 -350 1670 -350 {
lab=vss}
N 1000 -2010 1000 -1950 {lab=vdd}
N 1000 -2010 1040 -2010 {lab=vdd}
N 1000 -1760 1000 -1730 {lab=#net4}
N 1000 -1700 1000 -1590 {lab=vss}
N 940 -1700 960 -1700 {lab=#net4}
N 790 -1700 790 -1590 {lab=vss}
N 790 -1800 790 -1730 {lab=pcasc}
N 850 -2010 1000 -2010 {lab=vdd}
N 850 -1850 880 -1850 {lab=pcasc}
N 940 -1760 1000 -1760 {lab=#net4}
N 1000 -1820 1000 -1760 {lab=#net4}
N 940 -1760 940 -1700 {lab=#net4}
N 900 -1700 940 -1700 {lab=#net4}
N 850 -1850 850 -1800 {lab=pcasc}
N 790 -1800 850 -1800 {lab=pcasc}
N 830 -1850 850 -1850 {lab=pcasc}
N 790 -1820 790 -1800 {lab=pcasc}
N 430 -1670 460 -1670 {lab=vdd}
N 340 -1670 390 -1670 {lab=pcasc}
N 1000 -1920 1000 -1880 {lab=#net5}
N 900 -1590 1000 -1590 {lab=vss}
N 2410 -1540 2500 -1540 {
lab=vref}
N 910 -1950 960 -1950 {lab=vctrl}
N 160 -1540 230 -1540 {lab=cascDrain}
N -50 -1540 60 -1540 {lab=Iptat}
N 760 -350 780 -350 {
lab=vss}
N 450 -350 500 -350 {
lab=vss}
N 500 -390 500 -350 {lab=vss}
N 610 -350 760 -350 {
lab=vss}
N 560 -390 560 -350 {lab=vss}
N 820 -1360 880 -1360 {lab=PI1}
N 820 -1330 860 -1330 {lab=vdd}
N 530 -350 560 -350 {
lab=vss}
N 80 -1740 120 -1740 {lab=PwrUp}
N 200 -1740 260 -1740 {lab=PwrUp_N}
N 900 -1640 900 -1590 {lab=vss}
N 790 -1590 900 -1590 {lab=vss}
N 900 -1700 900 -1670 {lab=#net4}
N 830 -1700 900 -1700 {lab=#net4}
N 790 -2010 790 -1850 {lab=vdd}
N 850 -2010 850 -1910 {lab=vdd}
N 790 -2010 850 -2010 {lab=vdd}
N 850 -1880 850 -1850 {lab=pcasc}
N 1370 -350 1390 -350 {
lab=vss}
N 1390 -1190 1390 -350 {lab=vss}
N 2350 -1590 2350 -1540 {lab=vref}
N 2250 -1540 2350 -1540 {
lab=vref}
N 2350 -1540 2350 -1490 {lab=vref}
N 2410 -1540 2410 -1490 {lab=vref}
N 2410 -1590 2410 -1540 {lab=vref}
N 2350 -1540 2410 -1540 {
lab=vref}
N 1370 -1230 1410 -1230 {lab=vss}
N 1390 -1270 1430 -1270 {lab=outRes}
N 1390 -1190 1430 -1190 {lab=vss}
N 780 -640 780 -550 {
lab=Vbe1}
N 780 -1080 780 -720 {
lab=#net6}
N 760 -680 760 -350 {
lab=vss}
N 760 -680 880 -680 {lab=vss}
N 780 -720 900 -720 {lab=#net6}
N 780 -640 900 -640 {lab=Vbe1}
N 530 -620 620 -620 {lab=vss}
N 450 -1080 450 -880 {lab=#net7}
N 610 -1080 610 -880 {lab=#net8}
N 610 -880 650 -880 {lab=#net8}
N 610 -800 650 -800 {lab=#net9}
N 410 -800 450 -800 {lab=#net10}
N 410 -880 450 -880 {lab=#net7}
N 530 -620 530 -350 {lab=vss}
N 430 -840 530 -840 {lab=vss}
N 530 -840 530 -620 {lab=vss}
N 450 -800 450 -660 {lab=#net10}
N 610 -800 610 -660 {lab=#net9}
N 530 -840 630 -840 {lab=vss}
N 610 -660 640 -660 {lab=#net9}
N 420 -660 450 -660 {lab=#net10}
N 440 -620 530 -620 {lab=vss}
N 500 -350 530 -350 {
lab=vss}
N 420 -580 450 -580 {lab=#net11}
N 610 -580 640 -580 {lab=#net12}
N 610 -580 610 -470 {lab=#net12}
N 450 -580 450 -470 {lab=#net11}
N 450 -370 450 -350 {lab=vss}
N 230 -350 450 -350 {
lab=vss}
N 610 -370 610 -350 {lab=vss}
N 560 -350 610 -350 {
lab=vss}
C {devices/ipin.sym} 280 -2030 0 0 {name=p1 lab=vdd}
C {devices/ipin.sym} 280 -1850 0 0 {name=p2 lab=vss
}
C {devices/lab_wire.sym} 1560 -350 0 0 {name=p4 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 1270 -1450 0 0 {name=p5 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 1270 -1620 0 1 {name=p6 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 1540 -1450 0 0 {name=p9 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 1540 -1620 0 1 {name=p11 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 1830 -1400 0 0 {name=p12 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 2080 -1400 0 1 {name=p13 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 2230 -1580 0 1 {name=p17 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 550 -1330 0 0 {name=p18 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 150 -1330 0 1 {name=p19 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 860 -1330 0 0 {name=p20 sig_type=std_logic lab=vdd

}
C {JNW_TR_SKY130A/JNWTR_CAPX4.sym} 1010 -1020 0 0 {name=x14[9:0]}
C {JNW_TR_SKY130A/JNWTR_CAPX4.sym} 0 -1020 0 1 {name=x18[9:0]}
C {sky130_fd_pr/pnp_05v5.sym} 800 -520 0 1 {name=Q1
model=pnp_05v5_W3p40L3p40
m=8
spiceprefix=X
}
C {sky130_fd_pr/pnp_05v5.sym} 210 -520 0 0 {name=Q2
model=pnp_05v5_W3p40L3p40
m=1
spiceprefix=X
}
C {devices/lab_wire.sym} 930 -1090 0 1 {name=p23 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 140 -1090 0 1 {name=p24 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 930 -1260 0 0 {name=p25 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 140 -1260 0 0 {name=p26 sig_type=std_logic lab=vdd

}
C {devices/ipin.sym} 280 -2010 0 0 {name=p27 lab=vctrl}
C {devices/lab_wire.sym} 540 -1920 0 1 {name=p28 sig_type=std_logic lab=vdd

}
C {devices/ipin.sym} 2200 -1710 1 0 {name=p8 lab=PD}
C {devices/ipin.sym} 1810 -1370 0 0 {name=p10 lab=PB}
C {devices/ipin.sym} 2180 -1370 2 0 {name=p15 lab=PC}
C {devices/ipin.sym} 1390 -1690 1 0 {name=p16 lab=PA}
C {devices/ipin.sym} 870 -1250 2 1 {name=p31 lab=PI2}
C {devices/ipin.sym} 1280 -1990 0 0 {name=p32 lab=dummy}
C {devices/ipin.sym} 100 -1360 0 0 {name=p33 lab=PII1}
C {devices/ipin.sym} 880 -1360 2 0 {name=p34 lab=PI1}
C {devices/opin.sym} 2530 -1540 0 0 {name=p3 lab=vref}
C {devices/opin.sym} 1060 -1180 0 0 {name=p21 lab=vp}
C {devices/opin.sym} -50 -1180 2 0 {name=p22 lab=vn}
C {devices/ipin.sym} 40 -1250 0 0 {name=p29 lab=PII2}
C {devices/lab_wire.sym} 1280 -1870 0 1 {name=p30 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 1870 -1210 0 0 {name=x1[5:0]}
C {JNW_TR_SKY130A/JNWTR_CAPX1.sym} 2040 -1210 0 0 {name=x2[5:0]}
C {JNW_TR_SKY130A/JNWTR_CAPX4.sym} 2500 -1210 0 0 {name=x3[9:0]}
C {JNW_ATR_SKY130A/JNWATR_PCH_4C5F0.sym} 500 -1820 0 0 {name=x9 }
C {devices/vsource.sym} 540 -1610 0 0 {name=vipmos value=0 savecurrent=true}
C {devices/vsource.sym} 780 -1110 0 0 {name=vibigdiode value=0 savecurrent=true}
C {devices/lab_wire.sym} 1870 -1290 0 1 {name=p35 sig_type=std_logic lab=Hcharge

}
C {devices/lab_wire.sym} 2040 -1290 0 1 {name=p36 sig_type=std_logic lab=Lcharge

}
C {devices/lab_wire.sym} 1390 -1470 0 1 {name=p37 sig_type=std_logic lab=outRes

}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1180 -1540 0 0 {name=x1 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1450 -1540 0 0 {name=x3 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 780 -1420 1 0 {name=x6 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 230 -1420 3 1 {name=x7 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 50 -1180 0 0 {name=x11 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 840 -1180 0 0 {name=x12 }
C {devices/lab_wire.sym} 2230 -1490 0 1 {name=p42 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 1940 -1400 0 1 {name=p38 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 2140 -1540 0 0 {name=x5 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 1870 -1310 3 0 {name=x13 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 2040 -1310 1 1 {name=x17 }
C {JNW_TR_SKY130A/JNWTR_NCHDL.sym} 2380 -1450 3 0 {name=x23 }
C {JNW_TR_SKY130A/JNWTR_PCHDL.sym} 2380 -1630 1 0 {name=x24 }
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 2380 -1340 3 0 {name=x25 }
C {devices/lab_wire.sym} 2380 -1300 0 1 {name=p7 sig_type=std_logic lab=PD

}
C {devices/lab_wire.sym} 2340 -1380 0 0 {name=p14 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 2380 -1590 1 1 {name=p39 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 2380 -1490 1 0 {name=p40 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 2420 -1380 0 1 {name=p41 sig_type=std_logic lab=vss
}
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 1320 -1950 3 1 {name=x15 }
C {devices/lab_wire.sym} 540 -1760 0 1 {name=p43 sig_type=std_logic lab=pmosDrain

}
C {devices/vsource.sym} 610 -1110 0 0 {name=viCTAT1 value=0 savecurrent=true}
C {devices/lab_wire.sym} 230 -600 0 0 {name=p44 sig_type=std_logic lab=Vbe2

}
C {devices/vsource.sym} 450 -1110 0 0 {name=viCTAT2 value=0 savecurrent=true}
C {devices/vsource.sym} 230 -1110 0 0 {name=vidiode value=0 savecurrent=true}
C {devices/lab_wire.sym} 780 -580 0 1 {name=p45 sig_type=std_logic lab=Vbe1

}
C {devices/lab_wire.sym} -60 -530 0 1 {name=p55 sig_type=std_logic lab=vn

}
C {devices/lab_wire.sym} 1090 -530 0 1 {name=p56 sig_type=std_logic lab=vp

}
C {devices/ipin.sym} 280 -1990 0 0 {name=p57 lab=preChrg}
C {devices/lab_wire.sym} -100 -440 0 0 {name=p51 sig_type=std_logic lab=preChrg

}
C {devices/lab_wire.sym} 1130 -440 0 1 {name=p54 sig_type=std_logic lab=preChrg

}
C {devices/lab_wire.sym} 1630 -440 0 0 {name=p47 sig_type=std_logic lab=preChrg

}
C {devices/lab_wire.sym} 1800 -1540 0 0 {name=p46 sig_type=std_logic lab=topSw

}
C {devices/lab_wire.sym} 1670 -530 3 1 {name=p48 sig_type=std_logic lab=topSw

}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 1630 -440 0 0 {name=x29 }
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} -100 -440 0 0 {name=x26 }
C {JNW_ATR_SKY130A/JNWATR_NCH_2C5F0.sym} 1130 -440 0 1 {name=x27 }
C {devices/lab_wire.sym} 290 -1180 0 1 {name=p49 sig_type=std_logic lab=vnm
}
C {devices/lab_wire.sym} 670 -1180 0 0 {name=p50 sig_type=std_logic lab=vpm
}
C {devices/vsource.sym} 780 -1460 0 0 {name=vipmos1 value=0 savecurrent=true}
C {devices/vsource.sym} 230 -1480 0 0 {name=vipmos2 value=0 savecurrent=true}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 1390 -1270 1 0 {name=x4 }
C {JNW_ATR_SKY130A/JNWATR_PCH_4C5F0.sym} 960 -1950 0 0 {name=x56 }
C {devices/lab_wire.sym} 1020 -2010 0 1 {name=p123 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 950 -1950 0 0 {name=p124 sig_type=std_logic lab=vctrl

}
C {JNW_ATR_SKY130A/JNWATR_NCH_4C5F0.sym} 960 -1700 0 0 {name=x57 }
C {JNW_ATR_SKY130A/JNWATR_NCH_4C5F0.sym} 830 -1700 0 1 {name=x58[1:0]}
C {devices/lab_wire.sym} 850 -1850 0 1 {name=p125 sig_type=std_logic lab=pcasc

}
C {JNW_ATR_SKY130A/JNWATR_PCH_4C5F0.sym} 830 -1850 0 1 {name=x59 }
C {JNW_ATR_SKY130A/JNWATR_PCH_4C1F2.sym} 390 -1670 0 0 {name=x60 }
C {devices/lab_wire.sym} 460 -1670 0 0 {name=p126 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 340 -1670 0 1 {name=p127 sig_type=std_logic lab=pcasc

}
C {devices/vsource.sym} 1000 -1850 0 0 {name=vipmos4 value=0 savecurrent=true}
C {devices/lab_wire.sym} 910 -1590 0 1 {name=p128 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 480 -1820 0 0 {name=p52 sig_type=std_logic lab=vctrl

}
C {devices/lab_wire.sym} 540 -1540 0 1 {name=p61 sig_type=std_logic lab=cascDrain

}
C {devices/ipin.sym} 280 -1970 0 0 {name=p62 lab=s_Rdiscon_N}
C {devices/ipin.sym} 280 -1950 0 0 {name=p65 lab=s_PtatOut}
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 170 -1540 0 1 {name=x32 }
C {devices/lab_wire.sym} 80 -1580 0 0 {name=p53 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 80 -1490 0 0 {name=p58 sig_type=std_logic lab=vss
}
C {devices/lab_wire.sym} 110 -1580 0 1 {name=p59 sig_type=std_logic lab=s_PtatOut

}
C {devices/opin.sym} -50 -1540 2 0 {name=p60 lab=Iptat}
C {devices/lab_wire.sym} 650 -420 0 1 {name=p63 sig_type=std_logic lab=s_Rdiscon_N

}
C {devices/lab_wire.sym} 410 -420 0 0 {name=p64 sig_type=std_logic lab=s_Rdiscon_N

}
C {devices/ipin.sym} 280 -1870 0 0 {name=p68 lab=PwrUp
}
C {JNW_TR_SKY130A/JNWTR_IVX1_CV.sym} 120 -1740 0 0 {name=x16 }
C {devices/lab_wire.sym} 100 -1740 0 0 {name=p69 sig_type=std_logic lab=PwrUp}
C {devices/lab_wire.sym} 260 -1740 0 0 {name=p70 sig_type=std_logic lab=PwrUp_N}
C {devices/lab_wire.sym} 160 -1700 0 0 {name=p71 sig_type=std_logic lab=vss}
C {devices/lab_wire.sym} 160 -1780 0 0 {name=p72 sig_type=std_logic lab=vdd}
C {JNW_ATR_SKY130A/JNWATR_NCH_2C1F2.sym} 860 -1640 0 0 {name=x20 }
C {devices/lab_wire.sym} 860 -1640 0 0 {name=p73 sig_type=std_logic lab=PwrUp_N}
C {JNW_ATR_SKY130A/JNWATR_PCH_2C1F2.sym} 890 -1910 0 1 {name=x33 }
C {devices/lab_wire.sym} 890 -1910 0 1 {name=p75 sig_type=std_logic lab=PwrUp}
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 610 -660 1 0 {name=x206 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 900 -720 1 0 {name=x207 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 860 -720 1 0 {name=x208 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 820 -720 1 0 {name=x209 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 780 -720 1 0 {name=x210 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 640 -660 1 0 {name=x211 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 450 -660 3 1 {name=x212 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 420 -660 3 1 {name=x213 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 610 -880 1 0 {name=x214 }
C {JNW_TR_SKY130A/JNWTR_RPPO2.sym} 450 -880 3 1 {name=x215 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 410 -880 3 1 {name=x216 }
C {JNW_TR_SKY130A/JNWTR_RPPO4.sym} 650 -880 1 0 {name=x217 }
C {JNW_TR_SKY130A/JNWTR_RPPO16.sym} 1430 -1270 1 0 {name=x2 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 610 -480 1 0 {name=x8 }
C {JNW_TR_SKY130A/JNWTR_TGX2_CV.sym} 450 -480 3 1 {name=x10 }
C {devices/lab_wire.sym} 410 -390 0 0 {name=p66 sig_type=std_logic lab=vdd

}
C {devices/lab_wire.sym} 650 -390 0 1 {name=p67 sig_type=std_logic lab=vdd

}
